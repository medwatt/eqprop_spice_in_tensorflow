* SPICE netlist generated from TensorFlow model
V_in_0 L0_N0 0 DC -4.240739e+00
V_in_1 L0_N1 0 DC 4.240739e+00
V_in_2 L0_N2 0 DC -4.240739e+00
V_in_3 L0_N3 0 DC 4.240739e+00
V_in_4 L0_N4 0 DC -4.240739e+00
V_in_5 L0_N5 0 DC 4.240739e+00
V_in_6 L0_N6 0 DC -4.240739e+00
V_in_7 L0_N7 0 DC 4.240739e+00
V_in_8 L0_N8 0 DC -4.240739e+00
V_in_9 L0_N9 0 DC 4.240739e+00
V_in_10 L0_N10 0 DC -4.240739e+00
V_in_11 L0_N11 0 DC 4.240739e+00
V_in_12 L0_N12 0 DC -4.240739e+00
V_in_13 L0_N13 0 DC 4.240739e+00
V_in_14 L0_N14 0 DC -4.240739e+00
V_in_15 L0_N15 0 DC 4.240739e+00
V_in_16 L0_N16 0 DC -4.240739e+00
V_in_17 L0_N17 0 DC 4.240739e+00
V_in_18 L0_N18 0 DC -4.240739e+00
V_in_19 L0_N19 0 DC 4.240739e+00
V_in_20 L0_N20 0 DC -4.240739e+00
V_in_21 L0_N21 0 DC 4.240739e+00
V_in_22 L0_N22 0 DC -4.240739e+00
V_in_23 L0_N23 0 DC 4.240739e+00
V_in_24 L0_N24 0 DC -4.240739e+00
V_in_25 L0_N25 0 DC 4.240739e+00
V_in_26 L0_N26 0 DC -4.240739e+00
V_in_27 L0_N27 0 DC 4.240739e+00
V_in_28 L0_N28 0 DC -4.240739e+00
V_in_29 L0_N29 0 DC 4.240739e+00
V_in_30 L0_N30 0 DC -4.240739e+00
V_in_31 L0_N31 0 DC 4.240739e+00
V_in_32 L0_N32 0 DC -4.240739e+00
V_in_33 L0_N33 0 DC 4.240739e+00
V_in_34 L0_N34 0 DC -4.240739e+00
V_in_35 L0_N35 0 DC 4.240739e+00
V_in_36 L0_N36 0 DC -4.240739e+00
V_in_37 L0_N37 0 DC 4.240739e+00
V_in_38 L0_N38 0 DC -4.240739e+00
V_in_39 L0_N39 0 DC 4.240739e+00
V_in_40 L0_N40 0 DC -4.240739e+00
V_in_41 L0_N41 0 DC 4.240739e+00
V_in_42 L0_N42 0 DC -4.240739e+00
V_in_43 L0_N43 0 DC 4.240739e+00
V_in_44 L0_N44 0 DC -4.240739e+00
V_in_45 L0_N45 0 DC 4.240739e+00
V_in_46 L0_N46 0 DC -4.240739e+00
V_in_47 L0_N47 0 DC 4.240739e+00
V_in_48 L0_N48 0 DC -4.240739e+00
V_in_49 L0_N49 0 DC 4.240739e+00
V_in_50 L0_N50 0 DC -4.240739e+00
V_in_51 L0_N51 0 DC 4.240739e+00
V_in_52 L0_N52 0 DC -4.240739e+00
V_in_53 L0_N53 0 DC 4.240739e+00
V_in_54 L0_N54 0 DC -4.240739e+00
V_in_55 L0_N55 0 DC 4.240739e+00
V_in_56 L0_N56 0 DC -4.240739e+00
V_in_57 L0_N57 0 DC 4.240739e+00
V_in_58 L0_N58 0 DC -4.240739e+00
V_in_59 L0_N59 0 DC 4.240739e+00
V_in_60 L0_N60 0 DC -4.240739e+00
V_in_61 L0_N61 0 DC 4.240739e+00
V_in_62 L0_N62 0 DC -4.240739e+00
V_in_63 L0_N63 0 DC 4.240739e+00
V_in_64 L0_N64 0 DC -4.240739e+00
V_in_65 L0_N65 0 DC 4.240739e+00
V_in_66 L0_N66 0 DC -4.240739e+00
V_in_67 L0_N67 0 DC 4.240739e+00
V_in_68 L0_N68 0 DC -4.240739e+00
V_in_69 L0_N69 0 DC 4.240739e+00
V_in_70 L0_N70 0 DC -4.240739e+00
V_in_71 L0_N71 0 DC 4.240739e+00
V_in_72 L0_N72 0 DC -4.240739e+00
V_in_73 L0_N73 0 DC 4.240739e+00
V_in_74 L0_N74 0 DC -4.240739e+00
V_in_75 L0_N75 0 DC 4.240739e+00
V_in_76 L0_N76 0 DC -4.240739e+00
V_in_77 L0_N77 0 DC 4.240739e+00
V_in_78 L0_N78 0 DC -4.240739e+00
V_in_79 L0_N79 0 DC 4.240739e+00
V_in_80 L0_N80 0 DC -4.240739e+00
V_in_81 L0_N81 0 DC 4.240739e+00
V_in_82 L0_N82 0 DC -4.240739e+00
V_in_83 L0_N83 0 DC 4.240739e+00
V_in_84 L0_N84 0 DC -4.240739e+00
V_in_85 L0_N85 0 DC 4.240739e+00
V_in_86 L0_N86 0 DC -4.240739e+00
V_in_87 L0_N87 0 DC 4.240739e+00
V_in_88 L0_N88 0 DC -4.240739e+00
V_in_89 L0_N89 0 DC 4.240739e+00
V_in_90 L0_N90 0 DC -4.240739e+00
V_in_91 L0_N91 0 DC 4.240739e+00
V_in_92 L0_N92 0 DC -4.240739e+00
V_in_93 L0_N93 0 DC 4.240739e+00
V_in_94 L0_N94 0 DC -4.240739e+00
V_in_95 L0_N95 0 DC 4.240739e+00
V_in_96 L0_N96 0 DC -4.240739e+00
V_in_97 L0_N97 0 DC 4.240739e+00
V_in_98 L0_N98 0 DC -4.240739e+00
V_in_99 L0_N99 0 DC 4.240739e+00
V_in_100 L0_N100 0 DC -4.240739e+00
V_in_101 L0_N101 0 DC 4.240739e+00
V_in_102 L0_N102 0 DC -4.240739e+00
V_in_103 L0_N103 0 DC 4.240739e+00
V_in_104 L0_N104 0 DC -4.240739e+00
V_in_105 L0_N105 0 DC 4.240739e+00
V_in_106 L0_N106 0 DC -4.240739e+00
V_in_107 L0_N107 0 DC 4.240739e+00
V_in_108 L0_N108 0 DC -4.240739e+00
V_in_109 L0_N109 0 DC 4.240739e+00
V_in_110 L0_N110 0 DC -4.240739e+00
V_in_111 L0_N111 0 DC 4.240739e+00
V_in_112 L0_N112 0 DC -4.240739e+00
V_in_113 L0_N113 0 DC 4.240739e+00
V_in_114 L0_N114 0 DC -4.240739e+00
V_in_115 L0_N115 0 DC 4.240739e+00
V_in_116 L0_N116 0 DC -4.240739e+00
V_in_117 L0_N117 0 DC 4.240739e+00
V_in_118 L0_N118 0 DC -4.240739e+00
V_in_119 L0_N119 0 DC 4.240739e+00
V_in_120 L0_N120 0 DC -4.240739e+00
V_in_121 L0_N121 0 DC 4.240739e+00
V_in_122 L0_N122 0 DC -4.240739e+00
V_in_123 L0_N123 0 DC 4.240739e+00
V_in_124 L0_N124 0 DC -4.240739e+00
V_in_125 L0_N125 0 DC 4.240739e+00
V_in_126 L0_N126 0 DC -4.240739e+00
V_in_127 L0_N127 0 DC 4.240739e+00
V_in_128 L0_N128 0 DC -4.240739e+00
V_in_129 L0_N129 0 DC 4.240739e+00
V_in_130 L0_N130 0 DC -4.240739e+00
V_in_131 L0_N131 0 DC 4.240739e+00
V_in_132 L0_N132 0 DC -4.240739e+00
V_in_133 L0_N133 0 DC 4.240739e+00
V_in_134 L0_N134 0 DC -4.240739e+00
V_in_135 L0_N135 0 DC 4.240739e+00
V_in_136 L0_N136 0 DC -4.240739e+00
V_in_137 L0_N137 0 DC 4.240739e+00
V_in_138 L0_N138 0 DC -4.240739e+00
V_in_139 L0_N139 0 DC 4.240739e+00
V_in_140 L0_N140 0 DC -4.240739e+00
V_in_141 L0_N141 0 DC 4.240739e+00
V_in_142 L0_N142 0 DC -4.240739e+00
V_in_143 L0_N143 0 DC 4.240739e+00
V_in_144 L0_N144 0 DC -4.240739e+00
V_in_145 L0_N145 0 DC 4.240739e+00
V_in_146 L0_N146 0 DC -4.240739e+00
V_in_147 L0_N147 0 DC 4.240739e+00
V_in_148 L0_N148 0 DC -4.240739e+00
V_in_149 L0_N149 0 DC 4.240739e+00
V_in_150 L0_N150 0 DC -4.240739e+00
V_in_151 L0_N151 0 DC 4.240739e+00
V_in_152 L0_N152 0 DC -4.240739e+00
V_in_153 L0_N153 0 DC 4.240739e+00
V_in_154 L0_N154 0 DC -4.240739e+00
V_in_155 L0_N155 0 DC 4.240739e+00
V_in_156 L0_N156 0 DC -4.240739e+00
V_in_157 L0_N157 0 DC 4.240739e+00
V_in_158 L0_N158 0 DC -4.240739e+00
V_in_159 L0_N159 0 DC 4.240739e+00
V_in_160 L0_N160 0 DC -4.240739e+00
V_in_161 L0_N161 0 DC 4.240739e+00
V_in_162 L0_N162 0 DC -4.240739e+00
V_in_163 L0_N163 0 DC 4.240739e+00
V_in_164 L0_N164 0 DC -4.240739e+00
V_in_165 L0_N165 0 DC 4.240739e+00
V_in_166 L0_N166 0 DC -4.240739e+00
V_in_167 L0_N167 0 DC 4.240739e+00
V_in_168 L0_N168 0 DC -4.240739e+00
V_in_169 L0_N169 0 DC 4.240739e+00
V_in_170 L0_N170 0 DC -4.240739e+00
V_in_171 L0_N171 0 DC 4.240739e+00
V_in_172 L0_N172 0 DC -4.240739e+00
V_in_173 L0_N173 0 DC 4.240739e+00
V_in_174 L0_N174 0 DC -4.240739e+00
V_in_175 L0_N175 0 DC 4.240739e+00
V_in_176 L0_N176 0 DC -4.240739e+00
V_in_177 L0_N177 0 DC 4.240739e+00
V_in_178 L0_N178 0 DC -4.240739e+00
V_in_179 L0_N179 0 DC 4.240739e+00
V_in_180 L0_N180 0 DC -4.240739e+00
V_in_181 L0_N181 0 DC 4.240739e+00
V_in_182 L0_N182 0 DC -4.240739e+00
V_in_183 L0_N183 0 DC 4.240739e+00
V_in_184 L0_N184 0 DC -4.240739e+00
V_in_185 L0_N185 0 DC 4.240739e+00
V_in_186 L0_N186 0 DC -4.240739e+00
V_in_187 L0_N187 0 DC 4.240739e+00
V_in_188 L0_N188 0 DC -4.240739e+00
V_in_189 L0_N189 0 DC 4.240739e+00
V_in_190 L0_N190 0 DC -4.240739e+00
V_in_191 L0_N191 0 DC 4.240739e+00
V_in_192 L0_N192 0 DC -4.240739e+00
V_in_193 L0_N193 0 DC 4.240739e+00
V_in_194 L0_N194 0 DC -4.240739e+00
V_in_195 L0_N195 0 DC 4.240739e+00
V_in_196 L0_N196 0 DC -4.240739e+00
V_in_197 L0_N197 0 DC 4.240739e+00
V_in_198 L0_N198 0 DC -4.240739e+00
V_in_199 L0_N199 0 DC 4.240739e+00
V_in_200 L0_N200 0 DC -4.240739e+00
V_in_201 L0_N201 0 DC 4.240739e+00
V_in_202 L0_N202 0 DC -4.240739e+00
V_in_203 L0_N203 0 DC 4.240739e+00
V_in_204 L0_N204 0 DC -4.240739e+00
V_in_205 L0_N205 0 DC 4.240739e+00
V_in_206 L0_N206 0 DC -4.240739e+00
V_in_207 L0_N207 0 DC 4.240739e+00
V_in_208 L0_N208 0 DC -4.240739e+00
V_in_209 L0_N209 0 DC 4.240739e+00
V_in_210 L0_N210 0 DC -4.240739e+00
V_in_211 L0_N211 0 DC 4.240739e+00
V_in_212 L0_N212 0 DC -4.240739e+00
V_in_213 L0_N213 0 DC 4.240739e+00
V_in_214 L0_N214 0 DC -4.240739e+00
V_in_215 L0_N215 0 DC 4.240739e+00
V_in_216 L0_N216 0 DC -4.240739e+00
V_in_217 L0_N217 0 DC 4.240739e+00
V_in_218 L0_N218 0 DC -4.240739e+00
V_in_219 L0_N219 0 DC 4.240739e+00
V_in_220 L0_N220 0 DC -4.240739e+00
V_in_221 L0_N221 0 DC 4.240739e+00
V_in_222 L0_N222 0 DC -4.240739e+00
V_in_223 L0_N223 0 DC 4.240739e+00
V_in_224 L0_N224 0 DC -4.240739e+00
V_in_225 L0_N225 0 DC 4.240739e+00
V_in_226 L0_N226 0 DC -4.240739e+00
V_in_227 L0_N227 0 DC 4.240739e+00
V_in_228 L0_N228 0 DC -4.240739e+00
V_in_229 L0_N229 0 DC 4.240739e+00
V_in_230 L0_N230 0 DC -4.240739e+00
V_in_231 L0_N231 0 DC 4.240739e+00
V_in_232 L0_N232 0 DC -4.240739e+00
V_in_233 L0_N233 0 DC 4.240739e+00
V_in_234 L0_N234 0 DC -4.240739e+00
V_in_235 L0_N235 0 DC 4.240739e+00
V_in_236 L0_N236 0 DC -4.240739e+00
V_in_237 L0_N237 0 DC 4.240739e+00
V_in_238 L0_N238 0 DC -4.240739e+00
V_in_239 L0_N239 0 DC 4.240739e+00
V_in_240 L0_N240 0 DC -4.240739e+00
V_in_241 L0_N241 0 DC 4.240739e+00
V_in_242 L0_N242 0 DC -4.240739e+00
V_in_243 L0_N243 0 DC 4.240739e+00
V_in_244 L0_N244 0 DC -4.240739e+00
V_in_245 L0_N245 0 DC 4.240739e+00
V_in_246 L0_N246 0 DC -4.240739e+00
V_in_247 L0_N247 0 DC 4.240739e+00
V_in_248 L0_N248 0 DC -4.240739e+00
V_in_249 L0_N249 0 DC 4.240739e+00
V_in_250 L0_N250 0 DC -4.240739e+00
V_in_251 L0_N251 0 DC 4.240739e+00
V_in_252 L0_N252 0 DC -4.240739e+00
V_in_253 L0_N253 0 DC 4.240739e+00
V_in_254 L0_N254 0 DC -4.240739e+00
V_in_255 L0_N255 0 DC 4.240739e+00
V_in_256 L0_N256 0 DC -4.240739e+00
V_in_257 L0_N257 0 DC 4.240739e+00
V_in_258 L0_N258 0 DC -4.240739e+00
V_in_259 L0_N259 0 DC 4.240739e+00
V_in_260 L0_N260 0 DC -4.240739e+00
V_in_261 L0_N261 0 DC 4.240739e+00
V_in_262 L0_N262 0 DC -4.240739e+00
V_in_263 L0_N263 0 DC 4.240739e+00
V_in_264 L0_N264 0 DC -4.240739e+00
V_in_265 L0_N265 0 DC 4.240739e+00
V_in_266 L0_N266 0 DC -4.240739e+00
V_in_267 L0_N267 0 DC 4.240739e+00
V_in_268 L0_N268 0 DC -4.240739e+00
V_in_269 L0_N269 0 DC 4.240739e+00
V_in_270 L0_N270 0 DC -4.240739e+00
V_in_271 L0_N271 0 DC 4.240739e+00
V_in_272 L0_N272 0 DC -4.240739e+00
V_in_273 L0_N273 0 DC 4.240739e+00
V_in_274 L0_N274 0 DC -4.240739e+00
V_in_275 L0_N275 0 DC 4.240739e+00
V_in_276 L0_N276 0 DC -4.240739e+00
V_in_277 L0_N277 0 DC 4.240739e+00
V_in_278 L0_N278 0 DC -4.240739e+00
V_in_279 L0_N279 0 DC 4.240739e+00
V_in_280 L0_N280 0 DC -4.240739e+00
V_in_281 L0_N281 0 DC 4.240739e+00
V_in_282 L0_N282 0 DC -4.240739e+00
V_in_283 L0_N283 0 DC 4.240739e+00
V_in_284 L0_N284 0 DC -4.240739e+00
V_in_285 L0_N285 0 DC 4.240739e+00
V_in_286 L0_N286 0 DC -4.240739e+00
V_in_287 L0_N287 0 DC 4.240739e+00
V_in_288 L0_N288 0 DC -4.240739e+00
V_in_289 L0_N289 0 DC 4.240739e+00
V_in_290 L0_N290 0 DC -4.240739e+00
V_in_291 L0_N291 0 DC 4.240739e+00
V_in_292 L0_N292 0 DC -4.240739e+00
V_in_293 L0_N293 0 DC 4.240739e+00
V_in_294 L0_N294 0 DC -4.240739e+00
V_in_295 L0_N295 0 DC 4.240739e+00
V_in_296 L0_N296 0 DC -4.240739e+00
V_in_297 L0_N297 0 DC 4.240739e+00
V_in_298 L0_N298 0 DC -4.240739e+00
V_in_299 L0_N299 0 DC 4.240739e+00
V_in_300 L0_N300 0 DC -4.240739e+00
V_in_301 L0_N301 0 DC 4.240739e+00
V_in_302 L0_N302 0 DC -4.240739e+00
V_in_303 L0_N303 0 DC 4.240739e+00
V_in_304 L0_N304 0 DC -4.240739e+00
V_in_305 L0_N305 0 DC 4.240739e+00
V_in_306 L0_N306 0 DC -4.240739e+00
V_in_307 L0_N307 0 DC 4.240739e+00
V_in_308 L0_N308 0 DC -4.240739e+00
V_in_309 L0_N309 0 DC 4.240739e+00
V_in_310 L0_N310 0 DC -4.240739e+00
V_in_311 L0_N311 0 DC 4.240739e+00
V_in_312 L0_N312 0 DC -4.240739e+00
V_in_313 L0_N313 0 DC 4.240739e+00
V_in_314 L0_N314 0 DC -4.240739e+00
V_in_315 L0_N315 0 DC 4.240739e+00
V_in_316 L0_N316 0 DC -4.240739e+00
V_in_317 L0_N317 0 DC 4.240739e+00
V_in_318 L0_N318 0 DC -4.240739e+00
V_in_319 L0_N319 0 DC 4.240739e+00
V_in_320 L0_N320 0 DC -4.240739e+00
V_in_321 L0_N321 0 DC 4.240739e+00
V_in_322 L0_N322 0 DC -4.240739e+00
V_in_323 L0_N323 0 DC 4.240739e+00
V_in_324 L0_N324 0 DC -4.240739e+00
V_in_325 L0_N325 0 DC 4.240739e+00
V_in_326 L0_N326 0 DC -4.240739e+00
V_in_327 L0_N327 0 DC 4.240739e+00
V_in_328 L0_N328 0 DC -4.240739e+00
V_in_329 L0_N329 0 DC 4.240739e+00
V_in_330 L0_N330 0 DC -4.240739e+00
V_in_331 L0_N331 0 DC 4.240739e+00
V_in_332 L0_N332 0 DC -4.240739e+00
V_in_333 L0_N333 0 DC 4.240739e+00
V_in_334 L0_N334 0 DC -4.240739e+00
V_in_335 L0_N335 0 DC 4.240739e+00
V_in_336 L0_N336 0 DC -4.240739e+00
V_in_337 L0_N337 0 DC 4.240739e+00
V_in_338 L0_N338 0 DC -4.240739e+00
V_in_339 L0_N339 0 DC 4.240739e+00
V_in_340 L0_N340 0 DC -4.240739e+00
V_in_341 L0_N341 0 DC 4.240739e+00
V_in_342 L0_N342 0 DC -4.240739e+00
V_in_343 L0_N343 0 DC 4.240739e+00
V_in_344 L0_N344 0 DC -4.240739e+00
V_in_345 L0_N345 0 DC 4.240739e+00
V_in_346 L0_N346 0 DC -4.240739e+00
V_in_347 L0_N347 0 DC 4.240739e+00
V_in_348 L0_N348 0 DC -4.240739e+00
V_in_349 L0_N349 0 DC 4.240739e+00
V_in_350 L0_N350 0 DC -4.240739e+00
V_in_351 L0_N351 0 DC 4.240739e+00
V_in_352 L0_N352 0 DC -4.240739e+00
V_in_353 L0_N353 0 DC 4.240739e+00
V_in_354 L0_N354 0 DC -4.240739e+00
V_in_355 L0_N355 0 DC 4.240739e+00
V_in_356 L0_N356 0 DC -4.240739e+00
V_in_357 L0_N357 0 DC 4.240739e+00
V_in_358 L0_N358 0 DC -4.240739e+00
V_in_359 L0_N359 0 DC 4.240739e+00
V_in_360 L0_N360 0 DC -4.240739e+00
V_in_361 L0_N361 0 DC 4.240739e+00
V_in_362 L0_N362 0 DC -3.986181e+00
V_in_363 L0_N363 0 DC 3.986181e+00
V_in_364 L0_N364 0 DC -1.949715e+00
V_in_365 L0_N365 0 DC 1.949715e+00
V_in_366 L0_N366 0 DC 1.614100e+00
V_in_367 L0_N367 0 DC -1.614100e+00
V_in_368 L0_N368 0 DC 1.306922e+01
V_in_369 L0_N369 0 DC -1.306922e+01
V_in_370 L0_N370 0 DC 1.306922e+01
V_in_371 L0_N371 0 DC -1.306922e+01
V_in_372 L0_N372 0 DC 2.681536e+01
V_in_373 L0_N373 0 DC -2.681536e+01
V_in_374 L0_N374 0 DC 2.821543e+01
V_in_375 L0_N375 0 DC -2.821543e+01
V_in_376 L0_N376 0 DC 2.643353e+01
V_in_377 L0_N377 0 DC -2.643353e+01
V_in_378 L0_N378 0 DC 8.869009e+00
V_in_379 L0_N379 0 DC -8.869009e+00
V_in_380 L0_N380 0 DC -4.240739e+00
V_in_381 L0_N381 0 DC 4.240739e+00
V_in_382 L0_N382 0 DC -4.240739e+00
V_in_383 L0_N383 0 DC 4.240739e+00
V_in_384 L0_N384 0 DC -4.240739e+00
V_in_385 L0_N385 0 DC 4.240739e+00
V_in_386 L0_N386 0 DC -4.240739e+00
V_in_387 L0_N387 0 DC 4.240739e+00
V_in_388 L0_N388 0 DC -4.240739e+00
V_in_389 L0_N389 0 DC 4.240739e+00
V_in_390 L0_N390 0 DC -4.240739e+00
V_in_391 L0_N391 0 DC 4.240739e+00
V_in_392 L0_N392 0 DC -4.240739e+00
V_in_393 L0_N393 0 DC 4.240739e+00
V_in_394 L0_N394 0 DC -4.240739e+00
V_in_395 L0_N395 0 DC 4.240739e+00
V_in_396 L0_N396 0 DC -4.240739e+00
V_in_397 L0_N397 0 DC 4.240739e+00
V_in_398 L0_N398 0 DC -4.240739e+00
V_in_399 L0_N399 0 DC 4.240739e+00
V_in_400 L0_N400 0 DC -4.240739e+00
V_in_401 L0_N401 0 DC 4.240739e+00
V_in_402 L0_N402 0 DC -4.240739e+00
V_in_403 L0_N403 0 DC 4.240739e+00
V_in_404 L0_N404 0 DC -4.240739e+00
V_in_405 L0_N405 0 DC 4.240739e+00
V_in_406 L0_N406 0 DC -4.240739e+00
V_in_407 L0_N407 0 DC 4.240739e+00
V_in_408 L0_N408 0 DC -4.240739e+00
V_in_409 L0_N409 0 DC 4.240739e+00
V_in_410 L0_N410 0 DC -4.240739e+00
V_in_411 L0_N411 0 DC 4.240739e+00
V_in_412 L0_N412 0 DC -4.240739e+00
V_in_413 L0_N413 0 DC 4.240739e+00
V_in_414 L0_N414 0 DC -2.331552e+00
V_in_415 L0_N415 0 DC 2.331552e+00
V_in_416 L0_N416 0 DC 7.723497e+00
V_in_417 L0_N417 0 DC -7.723497e+00
V_in_418 L0_N418 0 DC 1.650576e+01
V_in_419 L0_N419 0 DC -1.650576e+01
V_in_420 L0_N420 0 DC 2.796088e+01
V_in_421 L0_N421 0 DC -2.796088e+01
V_in_422 L0_N422 0 DC 2.796088e+01
V_in_423 L0_N423 0 DC -2.796088e+01
V_in_424 L0_N424 0 DC 2.796088e+01
V_in_425 L0_N425 0 DC -2.796088e+01
V_in_426 L0_N426 0 DC 2.796088e+01
V_in_427 L0_N427 0 DC -2.796088e+01
V_in_428 L0_N428 0 DC 2.605169e+01
V_in_429 L0_N429 0 DC -2.605169e+01
V_in_430 L0_N430 0 DC 2.350611e+01
V_in_431 L0_N431 0 DC -2.350611e+01
V_in_432 L0_N432 0 DC 2.172420e+01
V_in_433 L0_N433 0 DC -2.172420e+01
V_in_434 L0_N434 0 DC 2.140298e-01
V_in_435 L0_N435 0 DC -2.140298e-01
V_in_436 L0_N436 0 DC -4.240739e+00
V_in_437 L0_N437 0 DC 4.240739e+00
V_in_438 L0_N438 0 DC -4.240739e+00
V_in_439 L0_N439 0 DC 4.240739e+00
V_in_440 L0_N440 0 DC -4.240739e+00
V_in_441 L0_N441 0 DC 4.240739e+00
V_in_442 L0_N442 0 DC -4.240739e+00
V_in_443 L0_N443 0 DC 4.240739e+00
V_in_444 L0_N444 0 DC -4.240739e+00
V_in_445 L0_N445 0 DC 4.240739e+00
V_in_446 L0_N446 0 DC -4.240739e+00
V_in_447 L0_N447 0 DC 4.240739e+00
V_in_448 L0_N448 0 DC -4.240739e+00
V_in_449 L0_N449 0 DC 4.240739e+00
V_in_450 L0_N450 0 DC -4.240739e+00
V_in_451 L0_N451 0 DC 4.240739e+00
V_in_452 L0_N452 0 DC -4.240739e+00
V_in_453 L0_N453 0 DC 4.240739e+00
V_in_454 L0_N454 0 DC -4.240739e+00
V_in_455 L0_N455 0 DC 4.240739e+00
V_in_456 L0_N456 0 DC -4.240739e+00
V_in_457 L0_N457 0 DC 4.240739e+00
V_in_458 L0_N458 0 DC -4.240739e+00
V_in_459 L0_N459 0 DC 4.240739e+00
V_in_460 L0_N460 0 DC -4.240739e+00
V_in_461 L0_N461 0 DC 4.240739e+00
V_in_462 L0_N462 0 DC -4.240739e+00
V_in_463 L0_N463 0 DC 4.240739e+00
V_in_464 L0_N464 0 DC -4.240739e+00
V_in_465 L0_N465 0 DC 4.240739e+00
V_in_466 L0_N466 0 DC -4.240739e+00
V_in_467 L0_N467 0 DC 4.240739e+00
V_in_468 L0_N468 0 DC -4.240739e+00
V_in_469 L0_N469 0 DC 4.240739e+00
V_in_470 L0_N470 0 DC 1.243282e+01
V_in_471 L0_N471 0 DC -1.243282e+01
V_in_472 L0_N472 0 DC 2.796088e+01
V_in_473 L0_N473 0 DC -2.796088e+01
V_in_474 L0_N474 0 DC 2.796088e+01
V_in_475 L0_N475 0 DC -2.796088e+01
V_in_476 L0_N476 0 DC 2.796088e+01
V_in_477 L0_N477 0 DC -2.796088e+01
V_in_478 L0_N478 0 DC 2.796088e+01
V_in_479 L0_N479 0 DC -2.796088e+01
V_in_480 L0_N480 0 DC 2.592441e+01
V_in_481 L0_N481 0 DC -2.592441e+01
V_in_482 L0_N482 0 DC 2.121508e+01
V_in_483 L0_N483 0 DC -2.121508e+01
V_in_484 L0_N484 0 DC 3.014170e+00
V_in_485 L0_N485 0 DC -3.014170e+00
V_in_486 L0_N486 0 DC -4.240739e+00
V_in_487 L0_N487 0 DC 4.240739e+00
V_in_488 L0_N488 0 DC -4.240739e+00
V_in_489 L0_N489 0 DC 4.240739e+00
V_in_490 L0_N490 0 DC -4.240739e+00
V_in_491 L0_N491 0 DC 4.240739e+00
V_in_492 L0_N492 0 DC -4.240739e+00
V_in_493 L0_N493 0 DC 4.240739e+00
V_in_494 L0_N494 0 DC -4.240739e+00
V_in_495 L0_N495 0 DC 4.240739e+00
V_in_496 L0_N496 0 DC -4.240739e+00
V_in_497 L0_N497 0 DC 4.240739e+00
V_in_498 L0_N498 0 DC -4.240739e+00
V_in_499 L0_N499 0 DC 4.240739e+00
V_in_500 L0_N500 0 DC -4.240739e+00
V_in_501 L0_N501 0 DC 4.240739e+00
V_in_502 L0_N502 0 DC -4.240739e+00
V_in_503 L0_N503 0 DC 4.240739e+00
V_in_504 L0_N504 0 DC -4.240739e+00
V_in_505 L0_N505 0 DC 4.240739e+00
V_in_506 L0_N506 0 DC -4.240739e+00
V_in_507 L0_N507 0 DC 4.240739e+00
V_in_508 L0_N508 0 DC -4.240739e+00
V_in_509 L0_N509 0 DC 4.240739e+00
V_in_510 L0_N510 0 DC -4.240739e+00
V_in_511 L0_N511 0 DC 4.240739e+00
V_in_512 L0_N512 0 DC -4.240739e+00
V_in_513 L0_N513 0 DC 4.240739e+00
V_in_514 L0_N514 0 DC -4.240739e+00
V_in_515 L0_N515 0 DC 4.240739e+00
V_in_516 L0_N516 0 DC -4.240739e+00
V_in_517 L0_N517 0 DC 4.240739e+00
V_in_518 L0_N518 0 DC -4.240739e+00
V_in_519 L0_N519 0 DC 4.240739e+00
V_in_520 L0_N520 0 DC -4.240739e+00
V_in_521 L0_N521 0 DC 4.240739e+00
V_in_522 L0_N522 0 DC -4.240739e+00
V_in_523 L0_N523 0 DC 4.240739e+00
V_in_524 L0_N524 0 DC 1.548752e+01
V_in_525 L0_N525 0 DC -1.548752e+01
V_in_526 L0_N526 0 DC 2.706992e+01
V_in_527 L0_N527 0 DC -2.706992e+01
V_in_528 L0_N528 0 DC 2.796088e+01
V_in_529 L0_N529 0 DC -2.796088e+01
V_in_530 L0_N530 0 DC 2.719720e+01
V_in_531 L0_N531 0 DC -2.719720e+01
V_in_532 L0_N532 0 DC 9.505405e+00
V_in_533 L0_N533 0 DC -9.505405e+00
V_in_534 L0_N534 0 DC 4.032403e+00
V_in_535 L0_N535 0 DC -4.032403e+00
V_in_536 L0_N536 0 DC 1.486821e+00
V_in_537 L0_N537 0 DC -1.486821e+00
V_in_538 L0_N538 0 DC -4.240739e+00
V_in_539 L0_N539 0 DC 4.240739e+00
V_in_540 L0_N540 0 DC -4.240739e+00
V_in_541 L0_N541 0 DC 4.240739e+00
V_in_542 L0_N542 0 DC -4.240739e+00
V_in_543 L0_N543 0 DC 4.240739e+00
V_in_544 L0_N544 0 DC -4.240739e+00
V_in_545 L0_N545 0 DC 4.240739e+00
V_in_546 L0_N546 0 DC -4.240739e+00
V_in_547 L0_N547 0 DC 4.240739e+00
V_in_548 L0_N548 0 DC -4.240739e+00
V_in_549 L0_N549 0 DC 4.240739e+00
V_in_550 L0_N550 0 DC -4.240739e+00
V_in_551 L0_N551 0 DC 4.240739e+00
V_in_552 L0_N552 0 DC -4.240739e+00
V_in_553 L0_N553 0 DC 4.240739e+00
V_in_554 L0_N554 0 DC -4.240739e+00
V_in_555 L0_N555 0 DC 4.240739e+00
V_in_556 L0_N556 0 DC -4.240739e+00
V_in_557 L0_N557 0 DC 4.240739e+00
V_in_558 L0_N558 0 DC -4.240739e+00
V_in_559 L0_N559 0 DC 4.240739e+00
V_in_560 L0_N560 0 DC -4.240739e+00
V_in_561 L0_N561 0 DC 4.240739e+00
V_in_562 L0_N562 0 DC -4.240739e+00
V_in_563 L0_N563 0 DC 4.240739e+00
V_in_564 L0_N564 0 DC -4.240739e+00
V_in_565 L0_N565 0 DC 4.240739e+00
V_in_566 L0_N566 0 DC -4.240739e+00
V_in_567 L0_N567 0 DC 4.240739e+00
V_in_568 L0_N568 0 DC -4.240739e+00
V_in_569 L0_N569 0 DC 4.240739e+00
V_in_570 L0_N570 0 DC -4.240739e+00
V_in_571 L0_N571 0 DC 4.240739e+00
V_in_572 L0_N572 0 DC -4.240739e+00
V_in_573 L0_N573 0 DC 4.240739e+00
V_in_574 L0_N574 0 DC -4.240739e+00
V_in_575 L0_N575 0 DC 4.240739e+00
V_in_576 L0_N576 0 DC -4.240739e+00
V_in_577 L0_N577 0 DC 4.240739e+00
V_in_578 L0_N578 0 DC -4.240739e+00
V_in_579 L0_N579 0 DC 4.240739e+00
V_in_580 L0_N580 0 DC 2.210604e+01
V_in_581 L0_N581 0 DC -2.210604e+01
V_in_582 L0_N582 0 DC 2.796088e+01
V_in_583 L0_N583 0 DC -2.796088e+01
V_in_584 L0_N584 0 DC 2.796088e+01
V_in_585 L0_N585 0 DC -2.796088e+01
V_in_586 L0_N586 0 DC 2.503346e+01
V_in_587 L0_N587 0 DC -2.503346e+01
V_in_588 L0_N588 0 DC -4.240739e+00
V_in_589 L0_N589 0 DC 4.240739e+00
V_in_590 L0_N590 0 DC -4.240739e+00
V_in_591 L0_N591 0 DC 4.240739e+00
V_in_592 L0_N592 0 DC -4.240739e+00
V_in_593 L0_N593 0 DC 4.240739e+00
V_in_594 L0_N594 0 DC -4.240739e+00
V_in_595 L0_N595 0 DC 4.240739e+00
V_in_596 L0_N596 0 DC -4.240739e+00
V_in_597 L0_N597 0 DC 4.240739e+00
V_in_598 L0_N598 0 DC -4.240739e+00
V_in_599 L0_N599 0 DC 4.240739e+00
V_in_600 L0_N600 0 DC -4.240739e+00
V_in_601 L0_N601 0 DC 4.240739e+00
V_in_602 L0_N602 0 DC -4.240739e+00
V_in_603 L0_N603 0 DC 4.240739e+00
V_in_604 L0_N604 0 DC -4.240739e+00
V_in_605 L0_N605 0 DC 4.240739e+00
V_in_606 L0_N606 0 DC -4.240739e+00
V_in_607 L0_N607 0 DC 4.240739e+00
V_in_608 L0_N608 0 DC -4.240739e+00
V_in_609 L0_N609 0 DC 4.240739e+00
V_in_610 L0_N610 0 DC -4.240739e+00
V_in_611 L0_N611 0 DC 4.240739e+00
V_in_612 L0_N612 0 DC -4.240739e+00
V_in_613 L0_N613 0 DC 4.240739e+00
V_in_614 L0_N614 0 DC -4.240739e+00
V_in_615 L0_N615 0 DC 4.240739e+00
V_in_616 L0_N616 0 DC -4.240739e+00
V_in_617 L0_N617 0 DC 4.240739e+00
V_in_618 L0_N618 0 DC -4.240739e+00
V_in_619 L0_N619 0 DC 4.240739e+00
V_in_620 L0_N620 0 DC -4.240739e+00
V_in_621 L0_N621 0 DC 4.240739e+00
V_in_622 L0_N622 0 DC -4.240739e+00
V_in_623 L0_N623 0 DC 4.240739e+00
V_in_624 L0_N624 0 DC -4.240739e+00
V_in_625 L0_N625 0 DC 4.240739e+00
V_in_626 L0_N626 0 DC -4.240739e+00
V_in_627 L0_N627 0 DC 4.240739e+00
V_in_628 L0_N628 0 DC -4.240739e+00
V_in_629 L0_N629 0 DC 4.240739e+00
V_in_630 L0_N630 0 DC -4.240739e+00
V_in_631 L0_N631 0 DC 4.240739e+00
V_in_632 L0_N632 0 DC -4.240739e+00
V_in_633 L0_N633 0 DC 4.240739e+00
V_in_634 L0_N634 0 DC -4.240739e+00
V_in_635 L0_N635 0 DC 4.240739e+00
V_in_636 L0_N636 0 DC 1.574208e+01
V_in_637 L0_N637 0 DC -1.574208e+01
V_in_638 L0_N638 0 DC 2.796088e+01
V_in_639 L0_N639 0 DC -2.796088e+01
V_in_640 L0_N640 0 DC 2.796088e+01
V_in_641 L0_N641 0 DC -2.796088e+01
V_in_642 L0_N642 0 DC 1.166915e+01
V_in_643 L0_N643 0 DC -1.166915e+01
V_in_644 L0_N644 0 DC -4.240739e+00
V_in_645 L0_N645 0 DC 4.240739e+00
V_in_646 L0_N646 0 DC -4.240739e+00
V_in_647 L0_N647 0 DC 4.240739e+00
V_in_648 L0_N648 0 DC -4.240739e+00
V_in_649 L0_N649 0 DC 4.240739e+00
V_in_650 L0_N650 0 DC -4.240739e+00
V_in_651 L0_N651 0 DC 4.240739e+00
V_in_652 L0_N652 0 DC -4.240739e+00
V_in_653 L0_N653 0 DC 4.240739e+00
V_in_654 L0_N654 0 DC -4.240739e+00
V_in_655 L0_N655 0 DC 4.240739e+00
V_in_656 L0_N656 0 DC -4.240739e+00
V_in_657 L0_N657 0 DC 4.240739e+00
V_in_658 L0_N658 0 DC -4.240739e+00
V_in_659 L0_N659 0 DC 4.240739e+00
V_in_660 L0_N660 0 DC -4.240739e+00
V_in_661 L0_N661 0 DC 4.240739e+00
V_in_662 L0_N662 0 DC -4.240739e+00
V_in_663 L0_N663 0 DC 4.240739e+00
V_in_664 L0_N664 0 DC -4.240739e+00
V_in_665 L0_N665 0 DC 4.240739e+00
V_in_666 L0_N666 0 DC -4.240739e+00
V_in_667 L0_N667 0 DC 4.240739e+00
V_in_668 L0_N668 0 DC -4.240739e+00
V_in_669 L0_N669 0 DC 4.240739e+00
V_in_670 L0_N670 0 DC -4.240739e+00
V_in_671 L0_N671 0 DC 4.240739e+00
V_in_672 L0_N672 0 DC -4.240739e+00
V_in_673 L0_N673 0 DC 4.240739e+00
V_in_674 L0_N674 0 DC -4.240739e+00
V_in_675 L0_N675 0 DC 4.240739e+00
V_in_676 L0_N676 0 DC -4.240739e+00
V_in_677 L0_N677 0 DC 4.240739e+00
V_in_678 L0_N678 0 DC -4.240739e+00
V_in_679 L0_N679 0 DC 4.240739e+00
V_in_680 L0_N680 0 DC -4.240739e+00
V_in_681 L0_N681 0 DC 4.240739e+00
V_in_682 L0_N682 0 DC -4.240739e+00
V_in_683 L0_N683 0 DC 4.240739e+00
V_in_684 L0_N684 0 DC -4.240739e+00
V_in_685 L0_N685 0 DC 4.240739e+00
V_in_686 L0_N686 0 DC -4.240739e+00
V_in_687 L0_N687 0 DC 4.240739e+00
V_in_688 L0_N688 0 DC -4.240739e+00
V_in_689 L0_N689 0 DC 4.240739e+00
V_in_690 L0_N690 0 DC -4.240739e+00
V_in_691 L0_N691 0 DC 4.240739e+00
V_in_692 L0_N692 0 DC 7.087102e+00
V_in_693 L0_N693 0 DC -7.087102e+00
V_in_694 L0_N694 0 DC 2.796088e+01
V_in_695 L0_N695 0 DC -2.796088e+01
V_in_696 L0_N696 0 DC 2.757904e+01
V_in_697 L0_N697 0 DC -2.757904e+01
V_in_698 L0_N698 0 DC 3.014170e+00
V_in_699 L0_N699 0 DC -3.014170e+00
V_in_700 L0_N700 0 DC -4.240739e+00
V_in_701 L0_N701 0 DC 4.240739e+00
V_in_702 L0_N702 0 DC -4.240739e+00
V_in_703 L0_N703 0 DC 4.240739e+00
V_in_704 L0_N704 0 DC -4.240739e+00
V_in_705 L0_N705 0 DC 4.240739e+00
V_in_706 L0_N706 0 DC -4.240739e+00
V_in_707 L0_N707 0 DC 4.240739e+00
V_in_708 L0_N708 0 DC -4.240739e+00
V_in_709 L0_N709 0 DC 4.240739e+00
V_in_710 L0_N710 0 DC -4.240739e+00
V_in_711 L0_N711 0 DC 4.240739e+00
V_in_712 L0_N712 0 DC -4.240739e+00
V_in_713 L0_N713 0 DC 4.240739e+00
V_in_714 L0_N714 0 DC -4.240739e+00
V_in_715 L0_N715 0 DC 4.240739e+00
V_in_716 L0_N716 0 DC -4.240739e+00
V_in_717 L0_N717 0 DC 4.240739e+00
V_in_718 L0_N718 0 DC -4.240739e+00
V_in_719 L0_N719 0 DC 4.240739e+00
V_in_720 L0_N720 0 DC -4.240739e+00
V_in_721 L0_N721 0 DC 4.240739e+00
V_in_722 L0_N722 0 DC -4.240739e+00
V_in_723 L0_N723 0 DC 4.240739e+00
V_in_724 L0_N724 0 DC -4.240739e+00
V_in_725 L0_N725 0 DC 4.240739e+00
V_in_726 L0_N726 0 DC -4.240739e+00
V_in_727 L0_N727 0 DC 4.240739e+00
V_in_728 L0_N728 0 DC -4.240739e+00
V_in_729 L0_N729 0 DC 4.240739e+00
V_in_730 L0_N730 0 DC -4.240739e+00
V_in_731 L0_N731 0 DC 4.240739e+00
V_in_732 L0_N732 0 DC -4.240739e+00
V_in_733 L0_N733 0 DC 4.240739e+00
V_in_734 L0_N734 0 DC -4.240739e+00
V_in_735 L0_N735 0 DC 4.240739e+00
V_in_736 L0_N736 0 DC -4.240739e+00
V_in_737 L0_N737 0 DC 4.240739e+00
V_in_738 L0_N738 0 DC -4.240739e+00
V_in_739 L0_N739 0 DC 4.240739e+00
V_in_740 L0_N740 0 DC -4.240739e+00
V_in_741 L0_N741 0 DC 4.240739e+00
V_in_742 L0_N742 0 DC -4.240739e+00
V_in_743 L0_N743 0 DC 4.240739e+00
V_in_744 L0_N744 0 DC -4.240739e+00
V_in_745 L0_N745 0 DC 4.240739e+00
V_in_746 L0_N746 0 DC -4.240739e+00
V_in_747 L0_N747 0 DC 4.240739e+00
V_in_748 L0_N748 0 DC 7.087102e+00
V_in_749 L0_N749 0 DC -7.087102e+00
V_in_750 L0_N750 0 DC 2.796088e+01
V_in_751 L0_N751 0 DC -2.796088e+01
V_in_752 L0_N752 0 DC 2.719720e+01
V_in_753 L0_N753 0 DC -2.719720e+01
V_in_754 L0_N754 0 DC -4.240739e+00
V_in_755 L0_N755 0 DC 4.240739e+00
V_in_756 L0_N756 0 DC -4.240739e+00
V_in_757 L0_N757 0 DC 4.240739e+00
V_in_758 L0_N758 0 DC -4.240739e+00
V_in_759 L0_N759 0 DC 4.240739e+00
V_in_760 L0_N760 0 DC -4.240739e+00
V_in_761 L0_N761 0 DC 4.240739e+00
V_in_762 L0_N762 0 DC -4.240739e+00
V_in_763 L0_N763 0 DC 4.240739e+00
V_in_764 L0_N764 0 DC -4.240739e+00
V_in_765 L0_N765 0 DC 4.240739e+00
V_in_766 L0_N766 0 DC -4.240739e+00
V_in_767 L0_N767 0 DC 4.240739e+00
V_in_768 L0_N768 0 DC -4.240739e+00
V_in_769 L0_N769 0 DC 4.240739e+00
V_in_770 L0_N770 0 DC -4.240739e+00
V_in_771 L0_N771 0 DC 4.240739e+00
V_in_772 L0_N772 0 DC -4.240739e+00
V_in_773 L0_N773 0 DC 4.240739e+00
V_in_774 L0_N774 0 DC -4.240739e+00
V_in_775 L0_N775 0 DC 4.240739e+00
V_in_776 L0_N776 0 DC -4.240739e+00
V_in_777 L0_N777 0 DC 4.240739e+00
V_in_778 L0_N778 0 DC -4.240739e+00
V_in_779 L0_N779 0 DC 4.240739e+00
V_in_780 L0_N780 0 DC -4.240739e+00
V_in_781 L0_N781 0 DC 4.240739e+00
V_in_782 L0_N782 0 DC -4.240739e+00
V_in_783 L0_N783 0 DC 4.240739e+00
V_in_784 L0_N784 0 DC -4.240739e+00
V_in_785 L0_N785 0 DC 4.240739e+00
V_in_786 L0_N786 0 DC -4.240739e+00
V_in_787 L0_N787 0 DC 4.240739e+00
V_in_788 L0_N788 0 DC -4.240739e+00
V_in_789 L0_N789 0 DC 4.240739e+00
V_in_790 L0_N790 0 DC -4.240739e+00
V_in_791 L0_N791 0 DC 4.240739e+00
V_in_792 L0_N792 0 DC -4.240739e+00
V_in_793 L0_N793 0 DC 4.240739e+00
V_in_794 L0_N794 0 DC -4.240739e+00
V_in_795 L0_N795 0 DC 4.240739e+00
V_in_796 L0_N796 0 DC -4.240739e+00
V_in_797 L0_N797 0 DC 4.240739e+00
V_in_798 L0_N798 0 DC -4.240739e+00
V_in_799 L0_N799 0 DC 4.240739e+00
V_in_800 L0_N800 0 DC -4.240739e+00
V_in_801 L0_N801 0 DC 4.240739e+00
V_in_802 L0_N802 0 DC -4.240739e+00
V_in_803 L0_N803 0 DC 4.240739e+00
V_in_804 L0_N804 0 DC 7.087102e+00
V_in_805 L0_N805 0 DC -7.087102e+00
V_in_806 L0_N806 0 DC 2.796088e+01
V_in_807 L0_N807 0 DC -2.796088e+01
V_in_808 L0_N808 0 DC 2.719720e+01
V_in_809 L0_N809 0 DC -2.719720e+01
V_in_810 L0_N810 0 DC -4.240739e+00
V_in_811 L0_N811 0 DC 4.240739e+00
V_in_812 L0_N812 0 DC -4.240739e+00
V_in_813 L0_N813 0 DC 4.240739e+00
V_in_814 L0_N814 0 DC -4.240739e+00
V_in_815 L0_N815 0 DC 4.240739e+00
V_in_816 L0_N816 0 DC -4.240739e+00
V_in_817 L0_N817 0 DC 4.240739e+00
V_in_818 L0_N818 0 DC -4.240739e+00
V_in_819 L0_N819 0 DC 4.240739e+00
V_in_820 L0_N820 0 DC -4.240739e+00
V_in_821 L0_N821 0 DC 4.240739e+00
V_in_822 L0_N822 0 DC -4.240739e+00
V_in_823 L0_N823 0 DC 4.240739e+00
V_in_824 L0_N824 0 DC -4.240739e+00
V_in_825 L0_N825 0 DC 4.240739e+00
V_in_826 L0_N826 0 DC -4.240739e+00
V_in_827 L0_N827 0 DC 4.240739e+00
V_in_828 L0_N828 0 DC -4.240739e+00
V_in_829 L0_N829 0 DC 4.240739e+00
V_in_830 L0_N830 0 DC -4.240739e+00
V_in_831 L0_N831 0 DC 4.240739e+00
V_in_832 L0_N832 0 DC -4.240739e+00
V_in_833 L0_N833 0 DC 4.240739e+00
V_in_834 L0_N834 0 DC -4.240739e+00
V_in_835 L0_N835 0 DC 4.240739e+00
V_in_836 L0_N836 0 DC -4.240739e+00
V_in_837 L0_N837 0 DC 4.240739e+00
V_in_838 L0_N838 0 DC -4.240739e+00
V_in_839 L0_N839 0 DC 4.240739e+00
V_in_840 L0_N840 0 DC -4.240739e+00
V_in_841 L0_N841 0 DC 4.240739e+00
V_in_842 L0_N842 0 DC -4.240739e+00
V_in_843 L0_N843 0 DC 4.240739e+00
V_in_844 L0_N844 0 DC -4.240739e+00
V_in_845 L0_N845 0 DC 4.240739e+00
V_in_846 L0_N846 0 DC -4.240739e+00
V_in_847 L0_N847 0 DC 4.240739e+00
V_in_848 L0_N848 0 DC -4.240739e+00
V_in_849 L0_N849 0 DC 4.240739e+00
V_in_850 L0_N850 0 DC -4.240739e+00
V_in_851 L0_N851 0 DC 4.240739e+00
V_in_852 L0_N852 0 DC -4.240739e+00
V_in_853 L0_N853 0 DC 4.240739e+00
V_in_854 L0_N854 0 DC -4.240739e+00
V_in_855 L0_N855 0 DC 4.240739e+00
V_in_856 L0_N856 0 DC -4.240739e+00
V_in_857 L0_N857 0 DC 4.240739e+00
V_in_858 L0_N858 0 DC -4.240739e+00
V_in_859 L0_N859 0 DC 4.240739e+00
V_in_860 L0_N860 0 DC 7.087102e+00
V_in_861 L0_N861 0 DC -7.087102e+00
V_in_862 L0_N862 0 DC 2.796088e+01
V_in_863 L0_N863 0 DC -2.796088e+01
V_in_864 L0_N864 0 DC 2.719720e+01
V_in_865 L0_N865 0 DC -2.719720e+01
V_in_866 L0_N866 0 DC -4.240739e+00
V_in_867 L0_N867 0 DC 4.240739e+00
V_in_868 L0_N868 0 DC -4.240739e+00
V_in_869 L0_N869 0 DC 4.240739e+00
V_in_870 L0_N870 0 DC -4.240739e+00
V_in_871 L0_N871 0 DC 4.240739e+00
V_in_872 L0_N872 0 DC -4.240739e+00
V_in_873 L0_N873 0 DC 4.240739e+00
V_in_874 L0_N874 0 DC -4.240739e+00
V_in_875 L0_N875 0 DC 4.240739e+00
V_in_876 L0_N876 0 DC -4.240739e+00
V_in_877 L0_N877 0 DC 4.240739e+00
V_in_878 L0_N878 0 DC -4.240739e+00
V_in_879 L0_N879 0 DC 4.240739e+00
V_in_880 L0_N880 0 DC -4.240739e+00
V_in_881 L0_N881 0 DC 4.240739e+00
V_in_882 L0_N882 0 DC -4.240739e+00
V_in_883 L0_N883 0 DC 4.240739e+00
V_in_884 L0_N884 0 DC -4.240739e+00
V_in_885 L0_N885 0 DC 4.240739e+00
V_in_886 L0_N886 0 DC -4.240739e+00
V_in_887 L0_N887 0 DC 4.240739e+00
V_in_888 L0_N888 0 DC -4.240739e+00
V_in_889 L0_N889 0 DC 4.240739e+00
V_in_890 L0_N890 0 DC -4.240739e+00
V_in_891 L0_N891 0 DC 4.240739e+00
V_in_892 L0_N892 0 DC -4.240739e+00
V_in_893 L0_N893 0 DC 4.240739e+00
V_in_894 L0_N894 0 DC -4.240739e+00
V_in_895 L0_N895 0 DC 4.240739e+00
V_in_896 L0_N896 0 DC -4.240739e+00
V_in_897 L0_N897 0 DC 4.240739e+00
V_in_898 L0_N898 0 DC -4.240739e+00
V_in_899 L0_N899 0 DC 4.240739e+00
V_in_900 L0_N900 0 DC -4.240739e+00
V_in_901 L0_N901 0 DC 4.240739e+00
V_in_902 L0_N902 0 DC -4.240739e+00
V_in_903 L0_N903 0 DC 4.240739e+00
V_in_904 L0_N904 0 DC -4.240739e+00
V_in_905 L0_N905 0 DC 4.240739e+00
V_in_906 L0_N906 0 DC -4.240739e+00
V_in_907 L0_N907 0 DC 4.240739e+00
V_in_908 L0_N908 0 DC -4.240739e+00
V_in_909 L0_N909 0 DC 4.240739e+00
V_in_910 L0_N910 0 DC -4.240739e+00
V_in_911 L0_N911 0 DC 4.240739e+00
V_in_912 L0_N912 0 DC -4.240739e+00
V_in_913 L0_N913 0 DC 4.240739e+00
V_in_914 L0_N914 0 DC -4.240739e+00
V_in_915 L0_N915 0 DC 4.240739e+00
V_in_916 L0_N916 0 DC -1.567878e+00
V_in_917 L0_N917 0 DC 1.567878e+00
V_in_918 L0_N918 0 DC 2.516073e+01
V_in_919 L0_N919 0 DC -2.516073e+01
V_in_920 L0_N920 0 DC 2.745176e+01
V_in_921 L0_N921 0 DC -2.745176e+01
V_in_922 L0_N922 0 DC 8.675071e-02
V_in_923 L0_N923 0 DC -8.675071e-02
V_in_924 L0_N924 0 DC -4.240739e+00
V_in_925 L0_N925 0 DC 4.240739e+00
V_in_926 L0_N926 0 DC -4.240739e+00
V_in_927 L0_N927 0 DC 4.240739e+00
V_in_928 L0_N928 0 DC -4.240739e+00
V_in_929 L0_N929 0 DC 4.240739e+00
V_in_930 L0_N930 0 DC -4.240739e+00
V_in_931 L0_N931 0 DC 4.240739e+00
V_in_932 L0_N932 0 DC -4.240739e+00
V_in_933 L0_N933 0 DC 4.240739e+00
V_in_934 L0_N934 0 DC -4.240739e+00
V_in_935 L0_N935 0 DC 4.240739e+00
V_in_936 L0_N936 0 DC -4.240739e+00
V_in_937 L0_N937 0 DC 4.240739e+00
V_in_938 L0_N938 0 DC -4.240739e+00
V_in_939 L0_N939 0 DC 4.240739e+00
V_in_940 L0_N940 0 DC -4.240739e+00
V_in_941 L0_N941 0 DC 4.240739e+00
V_in_942 L0_N942 0 DC -4.240739e+00
V_in_943 L0_N943 0 DC 4.240739e+00
V_in_944 L0_N944 0 DC -4.240739e+00
V_in_945 L0_N945 0 DC 4.240739e+00
V_in_946 L0_N946 0 DC -4.240739e+00
V_in_947 L0_N947 0 DC 4.240739e+00
V_in_948 L0_N948 0 DC -4.240739e+00
V_in_949 L0_N949 0 DC 4.240739e+00
V_in_950 L0_N950 0 DC -4.240739e+00
V_in_951 L0_N951 0 DC 4.240739e+00
V_in_952 L0_N952 0 DC -4.240739e+00
V_in_953 L0_N953 0 DC 4.240739e+00
V_in_954 L0_N954 0 DC -4.240739e+00
V_in_955 L0_N955 0 DC 4.240739e+00
V_in_956 L0_N956 0 DC -4.240739e+00
V_in_957 L0_N957 0 DC 4.240739e+00
V_in_958 L0_N958 0 DC -4.240739e+00
V_in_959 L0_N959 0 DC 4.240739e+00
V_in_960 L0_N960 0 DC -4.240739e+00
V_in_961 L0_N961 0 DC 4.240739e+00
V_in_962 L0_N962 0 DC -4.240739e+00
V_in_963 L0_N963 0 DC 4.240739e+00
V_in_964 L0_N964 0 DC -4.240739e+00
V_in_965 L0_N965 0 DC 4.240739e+00
V_in_966 L0_N966 0 DC -4.240739e+00
V_in_967 L0_N967 0 DC 4.240739e+00
V_in_968 L0_N968 0 DC -4.240739e+00
V_in_969 L0_N969 0 DC 4.240739e+00
V_in_970 L0_N970 0 DC -4.240739e+00
V_in_971 L0_N971 0 DC 4.240739e+00
V_in_972 L0_N972 0 DC -4.240739e+00
V_in_973 L0_N973 0 DC 4.240739e+00
V_in_974 L0_N974 0 DC 2.439706e+01
V_in_975 L0_N975 0 DC -2.439706e+01
V_in_976 L0_N976 0 DC 2.796088e+01
V_in_977 L0_N977 0 DC -2.796088e+01
V_in_978 L0_N978 0 DC 2.516073e+01
V_in_979 L0_N979 0 DC -2.516073e+01
V_in_980 L0_N980 0 DC 2.286971e+01
V_in_981 L0_N981 0 DC -2.286971e+01
V_in_982 L0_N982 0 DC 2.286971e+01
V_in_983 L0_N983 0 DC -2.286971e+01
V_in_984 L0_N984 0 DC 1.141459e+01
V_in_985 L0_N985 0 DC -1.141459e+01
V_in_986 L0_N986 0 DC -2.204273e+00
V_in_987 L0_N987 0 DC 2.204273e+00
V_in_988 L0_N988 0 DC -4.240739e+00
V_in_989 L0_N989 0 DC 4.240739e+00
V_in_990 L0_N990 0 DC -4.240739e+00
V_in_991 L0_N991 0 DC 4.240739e+00
V_in_992 L0_N992 0 DC -4.240739e+00
V_in_993 L0_N993 0 DC 4.240739e+00
V_in_994 L0_N994 0 DC -4.240739e+00
V_in_995 L0_N995 0 DC 4.240739e+00
V_in_996 L0_N996 0 DC -4.240739e+00
V_in_997 L0_N997 0 DC 4.240739e+00
V_in_998 L0_N998 0 DC -4.240739e+00
V_in_999 L0_N999 0 DC 4.240739e+00
V_in_1000 L0_N1000 0 DC -4.240739e+00
V_in_1001 L0_N1001 0 DC 4.240739e+00
V_in_1002 L0_N1002 0 DC -4.240739e+00
V_in_1003 L0_N1003 0 DC 4.240739e+00
V_in_1004 L0_N1004 0 DC -4.240739e+00
V_in_1005 L0_N1005 0 DC 4.240739e+00
V_in_1006 L0_N1006 0 DC -4.240739e+00
V_in_1007 L0_N1007 0 DC 4.240739e+00
V_in_1008 L0_N1008 0 DC -4.240739e+00
V_in_1009 L0_N1009 0 DC 4.240739e+00
V_in_1010 L0_N1010 0 DC -4.240739e+00
V_in_1011 L0_N1011 0 DC 4.240739e+00
V_in_1012 L0_N1012 0 DC -4.240739e+00
V_in_1013 L0_N1013 0 DC 4.240739e+00
V_in_1014 L0_N1014 0 DC -4.240739e+00
V_in_1015 L0_N1015 0 DC 4.240739e+00
V_in_1016 L0_N1016 0 DC -4.240739e+00
V_in_1017 L0_N1017 0 DC 4.240739e+00
V_in_1018 L0_N1018 0 DC -4.240739e+00
V_in_1019 L0_N1019 0 DC 4.240739e+00
V_in_1020 L0_N1020 0 DC -4.240739e+00
V_in_1021 L0_N1021 0 DC 4.240739e+00
V_in_1022 L0_N1022 0 DC -4.240739e+00
V_in_1023 L0_N1023 0 DC 4.240739e+00
V_in_1024 L0_N1024 0 DC -4.240739e+00
V_in_1025 L0_N1025 0 DC 4.240739e+00
V_in_1026 L0_N1026 0 DC -4.240739e+00
V_in_1027 L0_N1027 0 DC 4.240739e+00
V_in_1028 L0_N1028 0 DC -4.240739e+00
V_in_1029 L0_N1029 0 DC 4.240739e+00
V_in_1030 L0_N1030 0 DC 1.765127e+01
V_in_1031 L0_N1031 0 DC -1.765127e+01
V_in_1032 L0_N1032 0 DC 2.796088e+01
V_in_1033 L0_N1033 0 DC -2.796088e+01
V_in_1034 L0_N1034 0 DC 2.796088e+01
V_in_1035 L0_N1035 0 DC -2.796088e+01
V_in_1036 L0_N1036 0 DC 2.796088e+01
V_in_1037 L0_N1037 0 DC -2.796088e+01
V_in_1038 L0_N1038 0 DC 2.796088e+01
V_in_1039 L0_N1039 0 DC -2.796088e+01
V_in_1040 L0_N1040 0 DC 2.796088e+01
V_in_1041 L0_N1041 0 DC -2.796088e+01
V_in_1042 L0_N1042 0 DC 1.994229e+01
V_in_1043 L0_N1043 0 DC -1.994229e+01
V_in_1044 L0_N1044 0 DC 3.777845e+00
V_in_1045 L0_N1045 0 DC -3.777845e+00
V_in_1046 L0_N1046 0 DC -4.240739e+00
V_in_1047 L0_N1047 0 DC 4.240739e+00
V_in_1048 L0_N1048 0 DC -4.240739e+00
V_in_1049 L0_N1049 0 DC 4.240739e+00
V_in_1050 L0_N1050 0 DC -4.240739e+00
V_in_1051 L0_N1051 0 DC 4.240739e+00
V_in_1052 L0_N1052 0 DC -4.240739e+00
V_in_1053 L0_N1053 0 DC 4.240739e+00
V_in_1054 L0_N1054 0 DC -4.240739e+00
V_in_1055 L0_N1055 0 DC 4.240739e+00
V_in_1056 L0_N1056 0 DC -4.240739e+00
V_in_1057 L0_N1057 0 DC 4.240739e+00
V_in_1058 L0_N1058 0 DC -4.240739e+00
V_in_1059 L0_N1059 0 DC 4.240739e+00
V_in_1060 L0_N1060 0 DC -4.240739e+00
V_in_1061 L0_N1061 0 DC 4.240739e+00
V_in_1062 L0_N1062 0 DC -4.240739e+00
V_in_1063 L0_N1063 0 DC 4.240739e+00
V_in_1064 L0_N1064 0 DC -4.240739e+00
V_in_1065 L0_N1065 0 DC 4.240739e+00
V_in_1066 L0_N1066 0 DC -4.240739e+00
V_in_1067 L0_N1067 0 DC 4.240739e+00
V_in_1068 L0_N1068 0 DC -4.240739e+00
V_in_1069 L0_N1069 0 DC 4.240739e+00
V_in_1070 L0_N1070 0 DC -4.240739e+00
V_in_1071 L0_N1071 0 DC 4.240739e+00
V_in_1072 L0_N1072 0 DC -4.240739e+00
V_in_1073 L0_N1073 0 DC 4.240739e+00
V_in_1074 L0_N1074 0 DC -4.240739e+00
V_in_1075 L0_N1075 0 DC 4.240739e+00
V_in_1076 L0_N1076 0 DC -4.240739e+00
V_in_1077 L0_N1077 0 DC 4.240739e+00
V_in_1078 L0_N1078 0 DC -4.240739e+00
V_in_1079 L0_N1079 0 DC 4.240739e+00
V_in_1080 L0_N1080 0 DC -4.240739e+00
V_in_1081 L0_N1081 0 DC 4.240739e+00
V_in_1082 L0_N1082 0 DC -4.240739e+00
V_in_1083 L0_N1083 0 DC 4.240739e+00
V_in_1084 L0_N1084 0 DC -4.240739e+00
V_in_1085 L0_N1085 0 DC 4.240739e+00
V_in_1086 L0_N1086 0 DC -3.986181e+00
V_in_1087 L0_N1087 0 DC 3.986181e+00
V_in_1088 L0_N1088 0 DC 1.052364e+01
V_in_1089 L0_N1089 0 DC -1.052364e+01
V_in_1090 L0_N1090 0 DC 4.923357e+00
V_in_1091 L0_N1091 0 DC -4.923357e+00
V_in_1092 L0_N1092 0 DC 1.154187e+01
V_in_1093 L0_N1093 0 DC -1.154187e+01
V_in_1094 L0_N1094 0 DC 2.236059e+01
V_in_1095 L0_N1095 0 DC -2.236059e+01
V_in_1096 L0_N1096 0 DC 2.796088e+01
V_in_1097 L0_N1097 0 DC -2.796088e+01
V_in_1098 L0_N1098 0 DC 2.796088e+01
V_in_1099 L0_N1099 0 DC -2.796088e+01
V_in_1100 L0_N1100 0 DC 1.370562e+01
V_in_1101 L0_N1101 0 DC -1.370562e+01
V_in_1102 L0_N1102 0 DC -4.240739e+00
V_in_1103 L0_N1103 0 DC 4.240739e+00
V_in_1104 L0_N1104 0 DC -4.240739e+00
V_in_1105 L0_N1105 0 DC 4.240739e+00
V_in_1106 L0_N1106 0 DC -4.240739e+00
V_in_1107 L0_N1107 0 DC 4.240739e+00
V_in_1108 L0_N1108 0 DC -4.240739e+00
V_in_1109 L0_N1109 0 DC 4.240739e+00
V_in_1110 L0_N1110 0 DC -4.240739e+00
V_in_1111 L0_N1111 0 DC 4.240739e+00
V_in_1112 L0_N1112 0 DC -4.240739e+00
V_in_1113 L0_N1113 0 DC 4.240739e+00
V_in_1114 L0_N1114 0 DC -4.240739e+00
V_in_1115 L0_N1115 0 DC 4.240739e+00
V_in_1116 L0_N1116 0 DC -4.240739e+00
V_in_1117 L0_N1117 0 DC 4.240739e+00
V_in_1118 L0_N1118 0 DC -4.240739e+00
V_in_1119 L0_N1119 0 DC 4.240739e+00
V_in_1120 L0_N1120 0 DC -4.240739e+00
V_in_1121 L0_N1121 0 DC 4.240739e+00
V_in_1122 L0_N1122 0 DC -4.240739e+00
V_in_1123 L0_N1123 0 DC 4.240739e+00
V_in_1124 L0_N1124 0 DC -4.240739e+00
V_in_1125 L0_N1125 0 DC 4.240739e+00
V_in_1126 L0_N1126 0 DC -4.240739e+00
V_in_1127 L0_N1127 0 DC 4.240739e+00
V_in_1128 L0_N1128 0 DC -4.240739e+00
V_in_1129 L0_N1129 0 DC 4.240739e+00
V_in_1130 L0_N1130 0 DC -4.240739e+00
V_in_1131 L0_N1131 0 DC 4.240739e+00
V_in_1132 L0_N1132 0 DC -4.240739e+00
V_in_1133 L0_N1133 0 DC 4.240739e+00
V_in_1134 L0_N1134 0 DC -4.240739e+00
V_in_1135 L0_N1135 0 DC 4.240739e+00
V_in_1136 L0_N1136 0 DC -4.240739e+00
V_in_1137 L0_N1137 0 DC 4.240739e+00
V_in_1138 L0_N1138 0 DC -4.240739e+00
V_in_1139 L0_N1139 0 DC 4.240739e+00
V_in_1140 L0_N1140 0 DC -4.240739e+00
V_in_1141 L0_N1141 0 DC 4.240739e+00
V_in_1142 L0_N1142 0 DC -4.240739e+00
V_in_1143 L0_N1143 0 DC 4.240739e+00
V_in_1144 L0_N1144 0 DC -4.240739e+00
V_in_1145 L0_N1145 0 DC 4.240739e+00
V_in_1146 L0_N1146 0 DC -4.240739e+00
V_in_1147 L0_N1147 0 DC 4.240739e+00
V_in_1148 L0_N1148 0 DC -4.240739e+00
V_in_1149 L0_N1149 0 DC 4.240739e+00
V_in_1150 L0_N1150 0 DC -1.058761e+00
V_in_1151 L0_N1151 0 DC 1.058761e+00
V_in_1152 L0_N1152 0 DC 2.363339e+01
V_in_1153 L0_N1153 0 DC -2.363339e+01
V_in_1154 L0_N1154 0 DC 2.796088e+01
V_in_1155 L0_N1155 0 DC -2.796088e+01
V_in_1156 L0_N1156 0 DC 2.197876e+01
V_in_1157 L0_N1157 0 DC -2.197876e+01
V_in_1158 L0_N1158 0 DC -3.858902e+00
V_in_1159 L0_N1159 0 DC 3.858902e+00
V_in_1160 L0_N1160 0 DC -4.240739e+00
V_in_1161 L0_N1161 0 DC 4.240739e+00
V_in_1162 L0_N1162 0 DC -4.240739e+00
V_in_1163 L0_N1163 0 DC 4.240739e+00
V_in_1164 L0_N1164 0 DC -4.240739e+00
V_in_1165 L0_N1165 0 DC 4.240739e+00
V_in_1166 L0_N1166 0 DC -4.240739e+00
V_in_1167 L0_N1167 0 DC 4.240739e+00
V_in_1168 L0_N1168 0 DC -4.240739e+00
V_in_1169 L0_N1169 0 DC 4.240739e+00
V_in_1170 L0_N1170 0 DC -4.240739e+00
V_in_1171 L0_N1171 0 DC 4.240739e+00
V_in_1172 L0_N1172 0 DC -4.240739e+00
V_in_1173 L0_N1173 0 DC 4.240739e+00
V_in_1174 L0_N1174 0 DC -4.240739e+00
V_in_1175 L0_N1175 0 DC 4.240739e+00
V_in_1176 L0_N1176 0 DC -4.240739e+00
V_in_1177 L0_N1177 0 DC 4.240739e+00
V_in_1178 L0_N1178 0 DC -4.240739e+00
V_in_1179 L0_N1179 0 DC 4.240739e+00
V_in_1180 L0_N1180 0 DC -4.240739e+00
V_in_1181 L0_N1181 0 DC 4.240739e+00
V_in_1182 L0_N1182 0 DC -4.240739e+00
V_in_1183 L0_N1183 0 DC 4.240739e+00
V_in_1184 L0_N1184 0 DC -4.240739e+00
V_in_1185 L0_N1185 0 DC 4.240739e+00
V_in_1186 L0_N1186 0 DC -4.240739e+00
V_in_1187 L0_N1187 0 DC 4.240739e+00
V_in_1188 L0_N1188 0 DC -4.240739e+00
V_in_1189 L0_N1189 0 DC 4.240739e+00
V_in_1190 L0_N1190 0 DC -4.240739e+00
V_in_1191 L0_N1191 0 DC 4.240739e+00
V_in_1192 L0_N1192 0 DC -4.240739e+00
V_in_1193 L0_N1193 0 DC 4.240739e+00
V_in_1194 L0_N1194 0 DC -4.240739e+00
V_in_1195 L0_N1195 0 DC 4.240739e+00
V_in_1196 L0_N1196 0 DC -4.240739e+00
V_in_1197 L0_N1197 0 DC 4.240739e+00
V_in_1198 L0_N1198 0 DC -4.240739e+00
V_in_1199 L0_N1199 0 DC 4.240739e+00
V_in_1200 L0_N1200 0 DC -4.240739e+00
V_in_1201 L0_N1201 0 DC 4.240739e+00
V_in_1202 L0_N1202 0 DC -4.240739e+00
V_in_1203 L0_N1203 0 DC 4.240739e+00
V_in_1204 L0_N1204 0 DC -4.240739e+00
V_in_1205 L0_N1205 0 DC 4.240739e+00
V_in_1206 L0_N1206 0 DC -4.240739e+00
V_in_1207 L0_N1207 0 DC 4.240739e+00
V_in_1208 L0_N1208 0 DC 8.996288e+00
V_in_1209 L0_N1209 0 DC -8.996288e+00
V_in_1210 L0_N1210 0 DC 2.706992e+01
V_in_1211 L0_N1211 0 DC -2.706992e+01
V_in_1212 L0_N1212 0 DC 2.796088e+01
V_in_1213 L0_N1213 0 DC -2.796088e+01
V_in_1214 L0_N1214 0 DC -3.604343e+00
V_in_1215 L0_N1215 0 DC 3.604343e+00
V_in_1216 L0_N1216 0 DC -4.240739e+00
V_in_1217 L0_N1217 0 DC 4.240739e+00
V_in_1218 L0_N1218 0 DC -4.240739e+00
V_in_1219 L0_N1219 0 DC 4.240739e+00
V_in_1220 L0_N1220 0 DC -4.240739e+00
V_in_1221 L0_N1221 0 DC 4.240739e+00
V_in_1222 L0_N1222 0 DC -4.240739e+00
V_in_1223 L0_N1223 0 DC 4.240739e+00
V_in_1224 L0_N1224 0 DC -4.240739e+00
V_in_1225 L0_N1225 0 DC 4.240739e+00
V_in_1226 L0_N1226 0 DC -4.240739e+00
V_in_1227 L0_N1227 0 DC 4.240739e+00
V_in_1228 L0_N1228 0 DC -4.240739e+00
V_in_1229 L0_N1229 0 DC 4.240739e+00
V_in_1230 L0_N1230 0 DC -4.240739e+00
V_in_1231 L0_N1231 0 DC 4.240739e+00
V_in_1232 L0_N1232 0 DC -4.240739e+00
V_in_1233 L0_N1233 0 DC 4.240739e+00
V_in_1234 L0_N1234 0 DC -4.240739e+00
V_in_1235 L0_N1235 0 DC 4.240739e+00
V_in_1236 L0_N1236 0 DC -4.240739e+00
V_in_1237 L0_N1237 0 DC 4.240739e+00
V_in_1238 L0_N1238 0 DC -4.240739e+00
V_in_1239 L0_N1239 0 DC 4.240739e+00
V_in_1240 L0_N1240 0 DC -4.240739e+00
V_in_1241 L0_N1241 0 DC 4.240739e+00
V_in_1242 L0_N1242 0 DC -4.240739e+00
V_in_1243 L0_N1243 0 DC 4.240739e+00
V_in_1244 L0_N1244 0 DC -4.240739e+00
V_in_1245 L0_N1245 0 DC 4.240739e+00
V_in_1246 L0_N1246 0 DC -4.240739e+00
V_in_1247 L0_N1247 0 DC 4.240739e+00
V_in_1248 L0_N1248 0 DC -4.240739e+00
V_in_1249 L0_N1249 0 DC 4.240739e+00
V_in_1250 L0_N1250 0 DC -4.240739e+00
V_in_1251 L0_N1251 0 DC 4.240739e+00
V_in_1252 L0_N1252 0 DC -4.240739e+00
V_in_1253 L0_N1253 0 DC 4.240739e+00
V_in_1254 L0_N1254 0 DC -4.240739e+00
V_in_1255 L0_N1255 0 DC 4.240739e+00
V_in_1256 L0_N1256 0 DC -4.240739e+00
V_in_1257 L0_N1257 0 DC 4.240739e+00
V_in_1258 L0_N1258 0 DC -4.240739e+00
V_in_1259 L0_N1259 0 DC 4.240739e+00
V_in_1260 L0_N1260 0 DC -4.240739e+00
V_in_1261 L0_N1261 0 DC 4.240739e+00
V_in_1262 L0_N1262 0 DC -4.240739e+00
V_in_1263 L0_N1263 0 DC 4.240739e+00
V_in_1264 L0_N1264 0 DC -4.240739e+00
V_in_1265 L0_N1265 0 DC 4.240739e+00
V_in_1266 L0_N1266 0 DC 2.286971e+01
V_in_1267 L0_N1267 0 DC -2.286971e+01
V_in_1268 L0_N1268 0 DC 2.796088e+01
V_in_1269 L0_N1269 0 DC -2.796088e+01
V_in_1270 L0_N1270 0 DC -3.604343e+00
V_in_1271 L0_N1271 0 DC 3.604343e+00
V_in_1272 L0_N1272 0 DC -4.240739e+00
V_in_1273 L0_N1273 0 DC 4.240739e+00
V_in_1274 L0_N1274 0 DC -4.240739e+00
V_in_1275 L0_N1275 0 DC 4.240739e+00
V_in_1276 L0_N1276 0 DC -4.240739e+00
V_in_1277 L0_N1277 0 DC 4.240739e+00
V_in_1278 L0_N1278 0 DC -4.240739e+00
V_in_1279 L0_N1279 0 DC 4.240739e+00
V_in_1280 L0_N1280 0 DC -4.240739e+00
V_in_1281 L0_N1281 0 DC 4.240739e+00
V_in_1282 L0_N1282 0 DC -4.240739e+00
V_in_1283 L0_N1283 0 DC 4.240739e+00
V_in_1284 L0_N1284 0 DC -4.240739e+00
V_in_1285 L0_N1285 0 DC 4.240739e+00
V_in_1286 L0_N1286 0 DC -4.240739e+00
V_in_1287 L0_N1287 0 DC 4.240739e+00
V_in_1288 L0_N1288 0 DC -4.240739e+00
V_in_1289 L0_N1289 0 DC 4.240739e+00
V_in_1290 L0_N1290 0 DC -4.240739e+00
V_in_1291 L0_N1291 0 DC 4.240739e+00
V_in_1292 L0_N1292 0 DC -4.240739e+00
V_in_1293 L0_N1293 0 DC 4.240739e+00
V_in_1294 L0_N1294 0 DC -4.240739e+00
V_in_1295 L0_N1295 0 DC 4.240739e+00
V_in_1296 L0_N1296 0 DC -4.240739e+00
V_in_1297 L0_N1297 0 DC 4.240739e+00
V_in_1298 L0_N1298 0 DC -4.240739e+00
V_in_1299 L0_N1299 0 DC 4.240739e+00
V_in_1300 L0_N1300 0 DC -4.240739e+00
V_in_1301 L0_N1301 0 DC 4.240739e+00
V_in_1302 L0_N1302 0 DC -4.240739e+00
V_in_1303 L0_N1303 0 DC 4.240739e+00
V_in_1304 L0_N1304 0 DC -4.240739e+00
V_in_1305 L0_N1305 0 DC 4.240739e+00
V_in_1306 L0_N1306 0 DC -4.240739e+00
V_in_1307 L0_N1307 0 DC 4.240739e+00
V_in_1308 L0_N1308 0 DC -4.240739e+00
V_in_1309 L0_N1309 0 DC 4.240739e+00
V_in_1310 L0_N1310 0 DC -4.240739e+00
V_in_1311 L0_N1311 0 DC 4.240739e+00
V_in_1312 L0_N1312 0 DC -4.240739e+00
V_in_1313 L0_N1313 0 DC 4.240739e+00
V_in_1314 L0_N1314 0 DC -4.240739e+00
V_in_1315 L0_N1315 0 DC 4.240739e+00
V_in_1316 L0_N1316 0 DC -4.240739e+00
V_in_1317 L0_N1317 0 DC 4.240739e+00
V_in_1318 L0_N1318 0 DC -4.240739e+00
V_in_1319 L0_N1319 0 DC 4.240739e+00
V_in_1320 L0_N1320 0 DC -9.314822e-01
V_in_1321 L0_N1321 0 DC 9.314822e-01
V_in_1322 L0_N1322 0 DC 2.452434e+01
V_in_1323 L0_N1323 0 DC -2.452434e+01
V_in_1324 L0_N1324 0 DC 2.796088e+01
V_in_1325 L0_N1325 0 DC -2.796088e+01
V_in_1326 L0_N1326 0 DC -3.604343e+00
V_in_1327 L0_N1327 0 DC 3.604343e+00
V_in_1328 L0_N1328 0 DC -4.240739e+00
V_in_1329 L0_N1329 0 DC 4.240739e+00
V_in_1330 L0_N1330 0 DC -4.240739e+00
V_in_1331 L0_N1331 0 DC 4.240739e+00
V_in_1332 L0_N1332 0 DC -4.240739e+00
V_in_1333 L0_N1333 0 DC 4.240739e+00
V_in_1334 L0_N1334 0 DC -4.240739e+00
V_in_1335 L0_N1335 0 DC 4.240739e+00
V_in_1336 L0_N1336 0 DC -4.240739e+00
V_in_1337 L0_N1337 0 DC 4.240739e+00
V_in_1338 L0_N1338 0 DC -4.240739e+00
V_in_1339 L0_N1339 0 DC 4.240739e+00
V_in_1340 L0_N1340 0 DC -4.240739e+00
V_in_1341 L0_N1341 0 DC 4.240739e+00
V_in_1342 L0_N1342 0 DC -4.240739e+00
V_in_1343 L0_N1343 0 DC 4.240739e+00
V_in_1344 L0_N1344 0 DC -4.240739e+00
V_in_1345 L0_N1345 0 DC 4.240739e+00
V_in_1346 L0_N1346 0 DC -4.240739e+00
V_in_1347 L0_N1347 0 DC 4.240739e+00
V_in_1348 L0_N1348 0 DC -4.240739e+00
V_in_1349 L0_N1349 0 DC 4.240739e+00
V_in_1350 L0_N1350 0 DC -4.240739e+00
V_in_1351 L0_N1351 0 DC 4.240739e+00
V_in_1352 L0_N1352 0 DC -4.240739e+00
V_in_1353 L0_N1353 0 DC 4.240739e+00
V_in_1354 L0_N1354 0 DC -4.240739e+00
V_in_1355 L0_N1355 0 DC 4.240739e+00
V_in_1356 L0_N1356 0 DC -4.240739e+00
V_in_1357 L0_N1357 0 DC 4.240739e+00
V_in_1358 L0_N1358 0 DC -4.240739e+00
V_in_1359 L0_N1359 0 DC 4.240739e+00
V_in_1360 L0_N1360 0 DC -4.240739e+00
V_in_1361 L0_N1361 0 DC 4.240739e+00
V_in_1362 L0_N1362 0 DC -4.240739e+00
V_in_1363 L0_N1363 0 DC 4.240739e+00
V_in_1364 L0_N1364 0 DC -4.240739e+00
V_in_1365 L0_N1365 0 DC 4.240739e+00
V_in_1366 L0_N1366 0 DC -4.240739e+00
V_in_1367 L0_N1367 0 DC 4.240739e+00
V_in_1368 L0_N1368 0 DC -4.240739e+00
V_in_1369 L0_N1369 0 DC 4.240739e+00
V_in_1370 L0_N1370 0 DC -4.240739e+00
V_in_1371 L0_N1371 0 DC 4.240739e+00
V_in_1372 L0_N1372 0 DC -4.240739e+00
V_in_1373 L0_N1373 0 DC 4.240739e+00
V_in_1374 L0_N1374 0 DC -4.240739e+00
V_in_1375 L0_N1375 0 DC 4.240739e+00
V_in_1376 L0_N1376 0 DC 1.256010e+01
V_in_1377 L0_N1377 0 DC -1.256010e+01
V_in_1378 L0_N1378 0 DC 2.796088e+01
V_in_1379 L0_N1379 0 DC -2.796088e+01
V_in_1380 L0_N1380 0 DC 2.236059e+01
V_in_1381 L0_N1381 0 DC -2.236059e+01
V_in_1382 L0_N1382 0 DC -3.858902e+00
V_in_1383 L0_N1383 0 DC 3.858902e+00
V_in_1384 L0_N1384 0 DC -4.240739e+00
V_in_1385 L0_N1385 0 DC 4.240739e+00
V_in_1386 L0_N1386 0 DC -4.240739e+00
V_in_1387 L0_N1387 0 DC 4.240739e+00
V_in_1388 L0_N1388 0 DC -4.240739e+00
V_in_1389 L0_N1389 0 DC 4.240739e+00
V_in_1390 L0_N1390 0 DC -4.240739e+00
V_in_1391 L0_N1391 0 DC 4.240739e+00
V_in_1392 L0_N1392 0 DC -4.240739e+00
V_in_1393 L0_N1393 0 DC 4.240739e+00
V_in_1394 L0_N1394 0 DC -4.240739e+00
V_in_1395 L0_N1395 0 DC 4.240739e+00
V_in_1396 L0_N1396 0 DC -4.240739e+00
V_in_1397 L0_N1397 0 DC 4.240739e+00
V_in_1398 L0_N1398 0 DC -4.240739e+00
V_in_1399 L0_N1399 0 DC 4.240739e+00
V_in_1400 L0_N1400 0 DC -4.240739e+00
V_in_1401 L0_N1401 0 DC 4.240739e+00
V_in_1402 L0_N1402 0 DC -4.240739e+00
V_in_1403 L0_N1403 0 DC 4.240739e+00
V_in_1404 L0_N1404 0 DC -4.240739e+00
V_in_1405 L0_N1405 0 DC 4.240739e+00
V_in_1406 L0_N1406 0 DC -4.240739e+00
V_in_1407 L0_N1407 0 DC 4.240739e+00
V_in_1408 L0_N1408 0 DC -4.240739e+00
V_in_1409 L0_N1409 0 DC 4.240739e+00
V_in_1410 L0_N1410 0 DC -4.240739e+00
V_in_1411 L0_N1411 0 DC 4.240739e+00
V_in_1412 L0_N1412 0 DC -4.240739e+00
V_in_1413 L0_N1413 0 DC 4.240739e+00
V_in_1414 L0_N1414 0 DC -4.240739e+00
V_in_1415 L0_N1415 0 DC 4.240739e+00
V_in_1416 L0_N1416 0 DC -4.240739e+00
V_in_1417 L0_N1417 0 DC 4.240739e+00
V_in_1418 L0_N1418 0 DC -4.240739e+00
V_in_1419 L0_N1419 0 DC 4.240739e+00
V_in_1420 L0_N1420 0 DC -4.240739e+00
V_in_1421 L0_N1421 0 DC 4.240739e+00
V_in_1422 L0_N1422 0 DC -4.240739e+00
V_in_1423 L0_N1423 0 DC 4.240739e+00
V_in_1424 L0_N1424 0 DC -4.240739e+00
V_in_1425 L0_N1425 0 DC 4.240739e+00
V_in_1426 L0_N1426 0 DC -4.240739e+00
V_in_1427 L0_N1427 0 DC 4.240739e+00
V_in_1428 L0_N1428 0 DC -4.240739e+00
V_in_1429 L0_N1429 0 DC 4.240739e+00
V_in_1430 L0_N1430 0 DC -4.240739e+00
V_in_1431 L0_N1431 0 DC 4.240739e+00
V_in_1432 L0_N1432 0 DC 5.687031e+00
V_in_1433 L0_N1433 0 DC -5.687031e+00
V_in_1434 L0_N1434 0 DC 2.796088e+01
V_in_1435 L0_N1435 0 DC -2.796088e+01
V_in_1436 L0_N1436 0 DC 6.705264e+00
V_in_1437 L0_N1437 0 DC -6.705264e+00
V_in_1438 L0_N1438 0 DC -4.240739e+00
V_in_1439 L0_N1439 0 DC 4.240739e+00
V_in_1440 L0_N1440 0 DC -4.240739e+00
V_in_1441 L0_N1441 0 DC 4.240739e+00
V_in_1442 L0_N1442 0 DC -4.240739e+00
V_in_1443 L0_N1443 0 DC 4.240739e+00
V_in_1444 L0_N1444 0 DC -4.240739e+00
V_in_1445 L0_N1445 0 DC 4.240739e+00
V_in_1446 L0_N1446 0 DC -4.240739e+00
V_in_1447 L0_N1447 0 DC 4.240739e+00
V_in_1448 L0_N1448 0 DC -4.240739e+00
V_in_1449 L0_N1449 0 DC 4.240739e+00
V_in_1450 L0_N1450 0 DC -4.240739e+00
V_in_1451 L0_N1451 0 DC 4.240739e+00
V_in_1452 L0_N1452 0 DC -4.240739e+00
V_in_1453 L0_N1453 0 DC 4.240739e+00
V_in_1454 L0_N1454 0 DC -4.240739e+00
V_in_1455 L0_N1455 0 DC 4.240739e+00
V_in_1456 L0_N1456 0 DC -4.240739e+00
V_in_1457 L0_N1457 0 DC 4.240739e+00
V_in_1458 L0_N1458 0 DC -4.240739e+00
V_in_1459 L0_N1459 0 DC 4.240739e+00
V_in_1460 L0_N1460 0 DC -4.240739e+00
V_in_1461 L0_N1461 0 DC 4.240739e+00
V_in_1462 L0_N1462 0 DC -4.240739e+00
V_in_1463 L0_N1463 0 DC 4.240739e+00
V_in_1464 L0_N1464 0 DC -4.240739e+00
V_in_1465 L0_N1465 0 DC 4.240739e+00
V_in_1466 L0_N1466 0 DC -4.240739e+00
V_in_1467 L0_N1467 0 DC 4.240739e+00
V_in_1468 L0_N1468 0 DC -4.240739e+00
V_in_1469 L0_N1469 0 DC 4.240739e+00
V_in_1470 L0_N1470 0 DC -4.240739e+00
V_in_1471 L0_N1471 0 DC 4.240739e+00
V_in_1472 L0_N1472 0 DC -4.240739e+00
V_in_1473 L0_N1473 0 DC 4.240739e+00
V_in_1474 L0_N1474 0 DC -4.240739e+00
V_in_1475 L0_N1475 0 DC 4.240739e+00
V_in_1476 L0_N1476 0 DC -4.240739e+00
V_in_1477 L0_N1477 0 DC 4.240739e+00
V_in_1478 L0_N1478 0 DC -4.240739e+00
V_in_1479 L0_N1479 0 DC 4.240739e+00
V_in_1480 L0_N1480 0 DC -4.240739e+00
V_in_1481 L0_N1481 0 DC 4.240739e+00
V_in_1482 L0_N1482 0 DC -4.240739e+00
V_in_1483 L0_N1483 0 DC 4.240739e+00
V_in_1484 L0_N1484 0 DC -4.240739e+00
V_in_1485 L0_N1485 0 DC 4.240739e+00
V_in_1486 L0_N1486 0 DC -4.240739e+00
V_in_1487 L0_N1487 0 DC 4.240739e+00
V_in_1488 L0_N1488 0 DC -4.240739e+00
V_in_1489 L0_N1489 0 DC 4.240739e+00
V_in_1490 L0_N1490 0 DC -4.240739e+00
V_in_1491 L0_N1491 0 DC 4.240739e+00
V_in_1492 L0_N1492 0 DC -4.240739e+00
V_in_1493 L0_N1493 0 DC 4.240739e+00
V_in_1494 L0_N1494 0 DC -4.240739e+00
V_in_1495 L0_N1495 0 DC 4.240739e+00
V_in_1496 L0_N1496 0 DC -4.240739e+00
V_in_1497 L0_N1497 0 DC 4.240739e+00
V_in_1498 L0_N1498 0 DC -4.240739e+00
V_in_1499 L0_N1499 0 DC 4.240739e+00
V_in_1500 L0_N1500 0 DC -4.240739e+00
V_in_1501 L0_N1501 0 DC 4.240739e+00
V_in_1502 L0_N1502 0 DC -4.240739e+00
V_in_1503 L0_N1503 0 DC 4.240739e+00
V_in_1504 L0_N1504 0 DC -4.240739e+00
V_in_1505 L0_N1505 0 DC 4.240739e+00
V_in_1506 L0_N1506 0 DC -4.240739e+00
V_in_1507 L0_N1507 0 DC 4.240739e+00
V_in_1508 L0_N1508 0 DC -4.240739e+00
V_in_1509 L0_N1509 0 DC 4.240739e+00
V_in_1510 L0_N1510 0 DC -4.240739e+00
V_in_1511 L0_N1511 0 DC 4.240739e+00
V_in_1512 L0_N1512 0 DC -4.240739e+00
V_in_1513 L0_N1513 0 DC 4.240739e+00
V_in_1514 L0_N1514 0 DC -4.240739e+00
V_in_1515 L0_N1515 0 DC 4.240739e+00
V_in_1516 L0_N1516 0 DC -4.240739e+00
V_in_1517 L0_N1517 0 DC 4.240739e+00
V_in_1518 L0_N1518 0 DC -4.240739e+00
V_in_1519 L0_N1519 0 DC 4.240739e+00
V_in_1520 L0_N1520 0 DC -4.240739e+00
V_in_1521 L0_N1521 0 DC 4.240739e+00
V_in_1522 L0_N1522 0 DC -4.240739e+00
V_in_1523 L0_N1523 0 DC 4.240739e+00
V_in_1524 L0_N1524 0 DC -4.240739e+00
V_in_1525 L0_N1525 0 DC 4.240739e+00
V_in_1526 L0_N1526 0 DC -4.240739e+00
V_in_1527 L0_N1527 0 DC 4.240739e+00
V_in_1528 L0_N1528 0 DC -4.240739e+00
V_in_1529 L0_N1529 0 DC 4.240739e+00
V_in_1530 L0_N1530 0 DC -4.240739e+00
V_in_1531 L0_N1531 0 DC 4.240739e+00
V_in_1532 L0_N1532 0 DC -4.240739e+00
V_in_1533 L0_N1533 0 DC 4.240739e+00
V_in_1534 L0_N1534 0 DC -4.240739e+00
V_in_1535 L0_N1535 0 DC 4.240739e+00
V_in_1536 L0_N1536 0 DC -4.240739e+00
V_in_1537 L0_N1537 0 DC 4.240739e+00
V_in_1538 L0_N1538 0 DC -4.240739e+00
V_in_1539 L0_N1539 0 DC 4.240739e+00
V_in_1540 L0_N1540 0 DC -4.240739e+00
V_in_1541 L0_N1541 0 DC 4.240739e+00
V_in_1542 L0_N1542 0 DC -4.240739e+00
V_in_1543 L0_N1543 0 DC 4.240739e+00
V_in_1544 L0_N1544 0 DC -4.240739e+00
V_in_1545 L0_N1545 0 DC 4.240739e+00
V_in_1546 L0_N1546 0 DC -4.240739e+00
V_in_1547 L0_N1547 0 DC 4.240739e+00
V_in_1548 L0_N1548 0 DC -4.240739e+00
V_in_1549 L0_N1549 0 DC 4.240739e+00
V_in_1550 L0_N1550 0 DC -4.240739e+00
V_in_1551 L0_N1551 0 DC 4.240739e+00
V_in_1552 L0_N1552 0 DC -4.240739e+00
V_in_1553 L0_N1553 0 DC 4.240739e+00
V_in_1554 L0_N1554 0 DC -4.240739e+00
V_in_1555 L0_N1555 0 DC 4.240739e+00
V_in_1556 L0_N1556 0 DC -4.240739e+00
V_in_1557 L0_N1557 0 DC 4.240739e+00
V_in_1558 L0_N1558 0 DC -4.240739e+00
V_in_1559 L0_N1559 0 DC 4.240739e+00
V_in_1560 L0_N1560 0 DC -4.240739e+00
V_in_1561 L0_N1561 0 DC 4.240739e+00
V_in_1562 L0_N1562 0 DC -4.240739e+00
V_in_1563 L0_N1563 0 DC 4.240739e+00
V_in_1564 L0_N1564 0 DC -4.240739e+00
V_in_1565 L0_N1565 0 DC 4.240739e+00
V_in_1566 L0_N1566 0 DC -4.240739e+00
V_in_1567 L0_N1567 0 DC 4.240739e+00
*
R_Conv_1_0_0_0_0_0_0 L0_N0 L1_N0 3.0927915375e+05
R_Conv_1_0_0_0_0_0_1 L0_N1 L1_N0 3.6154472179e+05
R_Conv_1_0_0_0_0_1_0 L0_N2 L1_N0 1.2307612303e+05
R_Conv_1_0_0_0_0_1_1 L0_N3 L1_N0 1.3361401953e+06
R_Conv_1_0_0_0_0_2_0 L0_N4 L1_N0 1.1771240850e+06
R_Conv_1_0_0_0_0_2_1 L0_N5 L1_N0 1.1947062568e+05
R_Conv_1_0_0_0_1_0_0 L0_N56 L1_N0 3.4555602430e+05
R_Conv_1_0_0_0_1_0_1 L0_N57 L1_N0 1.2140655673e+05
R_Conv_1_0_0_0_1_1_0 L0_N58 L1_N0 2.0024008865e+05
R_Conv_1_0_0_0_1_1_1 L0_N59 L1_N0 1.3019124074e+05
R_Conv_1_0_0_0_1_2_0 L0_N60 L1_N0 1.1085089352e+05
R_Conv_1_0_0_0_1_2_1 L0_N61 L1_N0 2.5251460583e+05
R_Conv_1_0_0_0_2_0_0 L0_N112 L1_N0 1.1040315248e+05
R_Conv_1_0_0_0_2_0_1 L0_N113 L1_N0 1.2105931856e+05
R_Conv_1_0_0_0_2_1_0 L0_N114 L1_N0 1.0186236681e+05
R_Conv_1_0_0_0_2_1_1 L0_N115 L1_N0 3.8798345399e+05
R_Conv_1_0_0_0_2_2_0 L0_N116 L1_N0 4.4022254443e+06
R_Conv_1_0_0_0_2_2_1 L0_N117 L1_N0 1.5358515901e+05
*
R_Conv_1_0_0_1_0_0_0 L0_N0 L1_N1 1.2123709737e+05
R_Conv_1_0_0_1_0_0_1 L0_N1 L1_N1 1.0849154640e+05
R_Conv_1_0_0_1_0_1_0 L0_N2 L1_N1 2.0480317885e+05
R_Conv_1_0_0_1_0_1_1 L0_N3 L1_N1 1.6641635952e+05
R_Conv_1_0_0_1_0_2_0 L0_N4 L1_N1 1.1683261279e+06
R_Conv_1_0_0_1_0_2_1 L0_N5 L1_N1 1.1602008983e+05
R_Conv_1_0_0_1_1_0_0 L0_N56 L1_N1 1.2296662853e+05
R_Conv_1_0_0_1_1_0_1 L0_N57 L1_N1 1.6882235068e+05
R_Conv_1_0_0_1_1_1_0 L0_N58 L1_N1 1.0472083211e+05
R_Conv_1_0_0_1_1_1_1 L0_N59 L1_N1 2.1167619859e+05
R_Conv_1_0_0_1_1_2_0 L0_N60 L1_N1 1.3518319025e+05
R_Conv_1_0_0_1_1_2_1 L0_N61 L1_N1 1.4280846670e+05
R_Conv_1_0_0_1_2_0_0 L0_N112 L1_N1 1.1620759255e+05
R_Conv_1_0_0_1_2_0_1 L0_N113 L1_N1 1.6895116802e+05
R_Conv_1_0_0_1_2_1_0 L0_N114 L1_N1 1.2455043512e+06
R_Conv_1_0_0_1_2_1_1 L0_N115 L1_N1 1.1694022847e+05
R_Conv_1_0_0_1_2_2_0 L0_N116 L1_N1 1.5663616684e+06
R_Conv_1_0_0_1_2_2_1 L0_N117 L1_N1 2.1466641264e+05
*
R_Conv_1_0_1_0_0_0_0 L0_N4 L1_N2 3.0927915375e+05
R_Conv_1_0_1_0_0_0_1 L0_N5 L1_N2 3.6154472179e+05
R_Conv_1_0_1_0_0_1_0 L0_N6 L1_N2 1.2307612303e+05
R_Conv_1_0_1_0_0_1_1 L0_N7 L1_N2 1.3361401953e+06
R_Conv_1_0_1_0_0_2_0 L0_N8 L1_N2 1.1771240850e+06
R_Conv_1_0_1_0_0_2_1 L0_N9 L1_N2 1.1947062568e+05
R_Conv_1_0_1_0_1_0_0 L0_N60 L1_N2 3.4555602430e+05
R_Conv_1_0_1_0_1_0_1 L0_N61 L1_N2 1.2140655673e+05
R_Conv_1_0_1_0_1_1_0 L0_N62 L1_N2 2.0024008865e+05
R_Conv_1_0_1_0_1_1_1 L0_N63 L1_N2 1.3019124074e+05
R_Conv_1_0_1_0_1_2_0 L0_N64 L1_N2 1.1085089352e+05
R_Conv_1_0_1_0_1_2_1 L0_N65 L1_N2 2.5251460583e+05
R_Conv_1_0_1_0_2_0_0 L0_N116 L1_N2 1.1040315248e+05
R_Conv_1_0_1_0_2_0_1 L0_N117 L1_N2 1.2105931856e+05
R_Conv_1_0_1_0_2_1_0 L0_N118 L1_N2 1.0186236681e+05
R_Conv_1_0_1_0_2_1_1 L0_N119 L1_N2 3.8798345399e+05
R_Conv_1_0_1_0_2_2_0 L0_N120 L1_N2 4.4022254443e+06
R_Conv_1_0_1_0_2_2_1 L0_N121 L1_N2 1.5358515901e+05
*
R_Conv_1_0_1_1_0_0_0 L0_N4 L1_N3 1.2123709737e+05
R_Conv_1_0_1_1_0_0_1 L0_N5 L1_N3 1.0849154640e+05
R_Conv_1_0_1_1_0_1_0 L0_N6 L1_N3 2.0480317885e+05
R_Conv_1_0_1_1_0_1_1 L0_N7 L1_N3 1.6641635952e+05
R_Conv_1_0_1_1_0_2_0 L0_N8 L1_N3 1.1683261279e+06
R_Conv_1_0_1_1_0_2_1 L0_N9 L1_N3 1.1602008983e+05
R_Conv_1_0_1_1_1_0_0 L0_N60 L1_N3 1.2296662853e+05
R_Conv_1_0_1_1_1_0_1 L0_N61 L1_N3 1.6882235068e+05
R_Conv_1_0_1_1_1_1_0 L0_N62 L1_N3 1.0472083211e+05
R_Conv_1_0_1_1_1_1_1 L0_N63 L1_N3 2.1167619859e+05
R_Conv_1_0_1_1_1_2_0 L0_N64 L1_N3 1.3518319025e+05
R_Conv_1_0_1_1_1_2_1 L0_N65 L1_N3 1.4280846670e+05
R_Conv_1_0_1_1_2_0_0 L0_N116 L1_N3 1.1620759255e+05
R_Conv_1_0_1_1_2_0_1 L0_N117 L1_N3 1.6895116802e+05
R_Conv_1_0_1_1_2_1_0 L0_N118 L1_N3 1.2455043512e+06
R_Conv_1_0_1_1_2_1_1 L0_N119 L1_N3 1.1694022847e+05
R_Conv_1_0_1_1_2_2_0 L0_N120 L1_N3 1.5663616684e+06
R_Conv_1_0_1_1_2_2_1 L0_N121 L1_N3 2.1466641264e+05
*
R_Conv_1_0_2_0_0_0_0 L0_N8 L1_N4 3.0927915375e+05
R_Conv_1_0_2_0_0_0_1 L0_N9 L1_N4 3.6154472179e+05
R_Conv_1_0_2_0_0_1_0 L0_N10 L1_N4 1.2307612303e+05
R_Conv_1_0_2_0_0_1_1 L0_N11 L1_N4 1.3361401953e+06
R_Conv_1_0_2_0_0_2_0 L0_N12 L1_N4 1.1771240850e+06
R_Conv_1_0_2_0_0_2_1 L0_N13 L1_N4 1.1947062568e+05
R_Conv_1_0_2_0_1_0_0 L0_N64 L1_N4 3.4555602430e+05
R_Conv_1_0_2_0_1_0_1 L0_N65 L1_N4 1.2140655673e+05
R_Conv_1_0_2_0_1_1_0 L0_N66 L1_N4 2.0024008865e+05
R_Conv_1_0_2_0_1_1_1 L0_N67 L1_N4 1.3019124074e+05
R_Conv_1_0_2_0_1_2_0 L0_N68 L1_N4 1.1085089352e+05
R_Conv_1_0_2_0_1_2_1 L0_N69 L1_N4 2.5251460583e+05
R_Conv_1_0_2_0_2_0_0 L0_N120 L1_N4 1.1040315248e+05
R_Conv_1_0_2_0_2_0_1 L0_N121 L1_N4 1.2105931856e+05
R_Conv_1_0_2_0_2_1_0 L0_N122 L1_N4 1.0186236681e+05
R_Conv_1_0_2_0_2_1_1 L0_N123 L1_N4 3.8798345399e+05
R_Conv_1_0_2_0_2_2_0 L0_N124 L1_N4 4.4022254443e+06
R_Conv_1_0_2_0_2_2_1 L0_N125 L1_N4 1.5358515901e+05
*
R_Conv_1_0_2_1_0_0_0 L0_N8 L1_N5 1.2123709737e+05
R_Conv_1_0_2_1_0_0_1 L0_N9 L1_N5 1.0849154640e+05
R_Conv_1_0_2_1_0_1_0 L0_N10 L1_N5 2.0480317885e+05
R_Conv_1_0_2_1_0_1_1 L0_N11 L1_N5 1.6641635952e+05
R_Conv_1_0_2_1_0_2_0 L0_N12 L1_N5 1.1683261279e+06
R_Conv_1_0_2_1_0_2_1 L0_N13 L1_N5 1.1602008983e+05
R_Conv_1_0_2_1_1_0_0 L0_N64 L1_N5 1.2296662853e+05
R_Conv_1_0_2_1_1_0_1 L0_N65 L1_N5 1.6882235068e+05
R_Conv_1_0_2_1_1_1_0 L0_N66 L1_N5 1.0472083211e+05
R_Conv_1_0_2_1_1_1_1 L0_N67 L1_N5 2.1167619859e+05
R_Conv_1_0_2_1_1_2_0 L0_N68 L1_N5 1.3518319025e+05
R_Conv_1_0_2_1_1_2_1 L0_N69 L1_N5 1.4280846670e+05
R_Conv_1_0_2_1_2_0_0 L0_N120 L1_N5 1.1620759255e+05
R_Conv_1_0_2_1_2_0_1 L0_N121 L1_N5 1.6895116802e+05
R_Conv_1_0_2_1_2_1_0 L0_N122 L1_N5 1.2455043512e+06
R_Conv_1_0_2_1_2_1_1 L0_N123 L1_N5 1.1694022847e+05
R_Conv_1_0_2_1_2_2_0 L0_N124 L1_N5 1.5663616684e+06
R_Conv_1_0_2_1_2_2_1 L0_N125 L1_N5 2.1466641264e+05
*
R_Conv_1_0_3_0_0_0_0 L0_N12 L1_N6 3.0927915375e+05
R_Conv_1_0_3_0_0_0_1 L0_N13 L1_N6 3.6154472179e+05
R_Conv_1_0_3_0_0_1_0 L0_N14 L1_N6 1.2307612303e+05
R_Conv_1_0_3_0_0_1_1 L0_N15 L1_N6 1.3361401953e+06
R_Conv_1_0_3_0_0_2_0 L0_N16 L1_N6 1.1771240850e+06
R_Conv_1_0_3_0_0_2_1 L0_N17 L1_N6 1.1947062568e+05
R_Conv_1_0_3_0_1_0_0 L0_N68 L1_N6 3.4555602430e+05
R_Conv_1_0_3_0_1_0_1 L0_N69 L1_N6 1.2140655673e+05
R_Conv_1_0_3_0_1_1_0 L0_N70 L1_N6 2.0024008865e+05
R_Conv_1_0_3_0_1_1_1 L0_N71 L1_N6 1.3019124074e+05
R_Conv_1_0_3_0_1_2_0 L0_N72 L1_N6 1.1085089352e+05
R_Conv_1_0_3_0_1_2_1 L0_N73 L1_N6 2.5251460583e+05
R_Conv_1_0_3_0_2_0_0 L0_N124 L1_N6 1.1040315248e+05
R_Conv_1_0_3_0_2_0_1 L0_N125 L1_N6 1.2105931856e+05
R_Conv_1_0_3_0_2_1_0 L0_N126 L1_N6 1.0186236681e+05
R_Conv_1_0_3_0_2_1_1 L0_N127 L1_N6 3.8798345399e+05
R_Conv_1_0_3_0_2_2_0 L0_N128 L1_N6 4.4022254443e+06
R_Conv_1_0_3_0_2_2_1 L0_N129 L1_N6 1.5358515901e+05
*
R_Conv_1_0_3_1_0_0_0 L0_N12 L1_N7 1.2123709737e+05
R_Conv_1_0_3_1_0_0_1 L0_N13 L1_N7 1.0849154640e+05
R_Conv_1_0_3_1_0_1_0 L0_N14 L1_N7 2.0480317885e+05
R_Conv_1_0_3_1_0_1_1 L0_N15 L1_N7 1.6641635952e+05
R_Conv_1_0_3_1_0_2_0 L0_N16 L1_N7 1.1683261279e+06
R_Conv_1_0_3_1_0_2_1 L0_N17 L1_N7 1.1602008983e+05
R_Conv_1_0_3_1_1_0_0 L0_N68 L1_N7 1.2296662853e+05
R_Conv_1_0_3_1_1_0_1 L0_N69 L1_N7 1.6882235068e+05
R_Conv_1_0_3_1_1_1_0 L0_N70 L1_N7 1.0472083211e+05
R_Conv_1_0_3_1_1_1_1 L0_N71 L1_N7 2.1167619859e+05
R_Conv_1_0_3_1_1_2_0 L0_N72 L1_N7 1.3518319025e+05
R_Conv_1_0_3_1_1_2_1 L0_N73 L1_N7 1.4280846670e+05
R_Conv_1_0_3_1_2_0_0 L0_N124 L1_N7 1.1620759255e+05
R_Conv_1_0_3_1_2_0_1 L0_N125 L1_N7 1.6895116802e+05
R_Conv_1_0_3_1_2_1_0 L0_N126 L1_N7 1.2455043512e+06
R_Conv_1_0_3_1_2_1_1 L0_N127 L1_N7 1.1694022847e+05
R_Conv_1_0_3_1_2_2_0 L0_N128 L1_N7 1.5663616684e+06
R_Conv_1_0_3_1_2_2_1 L0_N129 L1_N7 2.1466641264e+05
*
R_Conv_1_0_4_0_0_0_0 L0_N16 L1_N8 3.0927915375e+05
R_Conv_1_0_4_0_0_0_1 L0_N17 L1_N8 3.6154472179e+05
R_Conv_1_0_4_0_0_1_0 L0_N18 L1_N8 1.2307612303e+05
R_Conv_1_0_4_0_0_1_1 L0_N19 L1_N8 1.3361401953e+06
R_Conv_1_0_4_0_0_2_0 L0_N20 L1_N8 1.1771240850e+06
R_Conv_1_0_4_0_0_2_1 L0_N21 L1_N8 1.1947062568e+05
R_Conv_1_0_4_0_1_0_0 L0_N72 L1_N8 3.4555602430e+05
R_Conv_1_0_4_0_1_0_1 L0_N73 L1_N8 1.2140655673e+05
R_Conv_1_0_4_0_1_1_0 L0_N74 L1_N8 2.0024008865e+05
R_Conv_1_0_4_0_1_1_1 L0_N75 L1_N8 1.3019124074e+05
R_Conv_1_0_4_0_1_2_0 L0_N76 L1_N8 1.1085089352e+05
R_Conv_1_0_4_0_1_2_1 L0_N77 L1_N8 2.5251460583e+05
R_Conv_1_0_4_0_2_0_0 L0_N128 L1_N8 1.1040315248e+05
R_Conv_1_0_4_0_2_0_1 L0_N129 L1_N8 1.2105931856e+05
R_Conv_1_0_4_0_2_1_0 L0_N130 L1_N8 1.0186236681e+05
R_Conv_1_0_4_0_2_1_1 L0_N131 L1_N8 3.8798345399e+05
R_Conv_1_0_4_0_2_2_0 L0_N132 L1_N8 4.4022254443e+06
R_Conv_1_0_4_0_2_2_1 L0_N133 L1_N8 1.5358515901e+05
*
R_Conv_1_0_4_1_0_0_0 L0_N16 L1_N9 1.2123709737e+05
R_Conv_1_0_4_1_0_0_1 L0_N17 L1_N9 1.0849154640e+05
R_Conv_1_0_4_1_0_1_0 L0_N18 L1_N9 2.0480317885e+05
R_Conv_1_0_4_1_0_1_1 L0_N19 L1_N9 1.6641635952e+05
R_Conv_1_0_4_1_0_2_0 L0_N20 L1_N9 1.1683261279e+06
R_Conv_1_0_4_1_0_2_1 L0_N21 L1_N9 1.1602008983e+05
R_Conv_1_0_4_1_1_0_0 L0_N72 L1_N9 1.2296662853e+05
R_Conv_1_0_4_1_1_0_1 L0_N73 L1_N9 1.6882235068e+05
R_Conv_1_0_4_1_1_1_0 L0_N74 L1_N9 1.0472083211e+05
R_Conv_1_0_4_1_1_1_1 L0_N75 L1_N9 2.1167619859e+05
R_Conv_1_0_4_1_1_2_0 L0_N76 L1_N9 1.3518319025e+05
R_Conv_1_0_4_1_1_2_1 L0_N77 L1_N9 1.4280846670e+05
R_Conv_1_0_4_1_2_0_0 L0_N128 L1_N9 1.1620759255e+05
R_Conv_1_0_4_1_2_0_1 L0_N129 L1_N9 1.6895116802e+05
R_Conv_1_0_4_1_2_1_0 L0_N130 L1_N9 1.2455043512e+06
R_Conv_1_0_4_1_2_1_1 L0_N131 L1_N9 1.1694022847e+05
R_Conv_1_0_4_1_2_2_0 L0_N132 L1_N9 1.5663616684e+06
R_Conv_1_0_4_1_2_2_1 L0_N133 L1_N9 2.1466641264e+05
*
R_Conv_1_0_5_0_0_0_0 L0_N20 L1_N10 3.0927915375e+05
R_Conv_1_0_5_0_0_0_1 L0_N21 L1_N10 3.6154472179e+05
R_Conv_1_0_5_0_0_1_0 L0_N22 L1_N10 1.2307612303e+05
R_Conv_1_0_5_0_0_1_1 L0_N23 L1_N10 1.3361401953e+06
R_Conv_1_0_5_0_0_2_0 L0_N24 L1_N10 1.1771240850e+06
R_Conv_1_0_5_0_0_2_1 L0_N25 L1_N10 1.1947062568e+05
R_Conv_1_0_5_0_1_0_0 L0_N76 L1_N10 3.4555602430e+05
R_Conv_1_0_5_0_1_0_1 L0_N77 L1_N10 1.2140655673e+05
R_Conv_1_0_5_0_1_1_0 L0_N78 L1_N10 2.0024008865e+05
R_Conv_1_0_5_0_1_1_1 L0_N79 L1_N10 1.3019124074e+05
R_Conv_1_0_5_0_1_2_0 L0_N80 L1_N10 1.1085089352e+05
R_Conv_1_0_5_0_1_2_1 L0_N81 L1_N10 2.5251460583e+05
R_Conv_1_0_5_0_2_0_0 L0_N132 L1_N10 1.1040315248e+05
R_Conv_1_0_5_0_2_0_1 L0_N133 L1_N10 1.2105931856e+05
R_Conv_1_0_5_0_2_1_0 L0_N134 L1_N10 1.0186236681e+05
R_Conv_1_0_5_0_2_1_1 L0_N135 L1_N10 3.8798345399e+05
R_Conv_1_0_5_0_2_2_0 L0_N136 L1_N10 4.4022254443e+06
R_Conv_1_0_5_0_2_2_1 L0_N137 L1_N10 1.5358515901e+05
*
R_Conv_1_0_5_1_0_0_0 L0_N20 L1_N11 1.2123709737e+05
R_Conv_1_0_5_1_0_0_1 L0_N21 L1_N11 1.0849154640e+05
R_Conv_1_0_5_1_0_1_0 L0_N22 L1_N11 2.0480317885e+05
R_Conv_1_0_5_1_0_1_1 L0_N23 L1_N11 1.6641635952e+05
R_Conv_1_0_5_1_0_2_0 L0_N24 L1_N11 1.1683261279e+06
R_Conv_1_0_5_1_0_2_1 L0_N25 L1_N11 1.1602008983e+05
R_Conv_1_0_5_1_1_0_0 L0_N76 L1_N11 1.2296662853e+05
R_Conv_1_0_5_1_1_0_1 L0_N77 L1_N11 1.6882235068e+05
R_Conv_1_0_5_1_1_1_0 L0_N78 L1_N11 1.0472083211e+05
R_Conv_1_0_5_1_1_1_1 L0_N79 L1_N11 2.1167619859e+05
R_Conv_1_0_5_1_1_2_0 L0_N80 L1_N11 1.3518319025e+05
R_Conv_1_0_5_1_1_2_1 L0_N81 L1_N11 1.4280846670e+05
R_Conv_1_0_5_1_2_0_0 L0_N132 L1_N11 1.1620759255e+05
R_Conv_1_0_5_1_2_0_1 L0_N133 L1_N11 1.6895116802e+05
R_Conv_1_0_5_1_2_1_0 L0_N134 L1_N11 1.2455043512e+06
R_Conv_1_0_5_1_2_1_1 L0_N135 L1_N11 1.1694022847e+05
R_Conv_1_0_5_1_2_2_0 L0_N136 L1_N11 1.5663616684e+06
R_Conv_1_0_5_1_2_2_1 L0_N137 L1_N11 2.1466641264e+05
*
R_Conv_1_0_6_0_0_0_0 L0_N24 L1_N12 3.0927915375e+05
R_Conv_1_0_6_0_0_0_1 L0_N25 L1_N12 3.6154472179e+05
R_Conv_1_0_6_0_0_1_0 L0_N26 L1_N12 1.2307612303e+05
R_Conv_1_0_6_0_0_1_1 L0_N27 L1_N12 1.3361401953e+06
R_Conv_1_0_6_0_0_2_0 L0_N28 L1_N12 1.1771240850e+06
R_Conv_1_0_6_0_0_2_1 L0_N29 L1_N12 1.1947062568e+05
R_Conv_1_0_6_0_1_0_0 L0_N80 L1_N12 3.4555602430e+05
R_Conv_1_0_6_0_1_0_1 L0_N81 L1_N12 1.2140655673e+05
R_Conv_1_0_6_0_1_1_0 L0_N82 L1_N12 2.0024008865e+05
R_Conv_1_0_6_0_1_1_1 L0_N83 L1_N12 1.3019124074e+05
R_Conv_1_0_6_0_1_2_0 L0_N84 L1_N12 1.1085089352e+05
R_Conv_1_0_6_0_1_2_1 L0_N85 L1_N12 2.5251460583e+05
R_Conv_1_0_6_0_2_0_0 L0_N136 L1_N12 1.1040315248e+05
R_Conv_1_0_6_0_2_0_1 L0_N137 L1_N12 1.2105931856e+05
R_Conv_1_0_6_0_2_1_0 L0_N138 L1_N12 1.0186236681e+05
R_Conv_1_0_6_0_2_1_1 L0_N139 L1_N12 3.8798345399e+05
R_Conv_1_0_6_0_2_2_0 L0_N140 L1_N12 4.4022254443e+06
R_Conv_1_0_6_0_2_2_1 L0_N141 L1_N12 1.5358515901e+05
*
R_Conv_1_0_6_1_0_0_0 L0_N24 L1_N13 1.2123709737e+05
R_Conv_1_0_6_1_0_0_1 L0_N25 L1_N13 1.0849154640e+05
R_Conv_1_0_6_1_0_1_0 L0_N26 L1_N13 2.0480317885e+05
R_Conv_1_0_6_1_0_1_1 L0_N27 L1_N13 1.6641635952e+05
R_Conv_1_0_6_1_0_2_0 L0_N28 L1_N13 1.1683261279e+06
R_Conv_1_0_6_1_0_2_1 L0_N29 L1_N13 1.1602008983e+05
R_Conv_1_0_6_1_1_0_0 L0_N80 L1_N13 1.2296662853e+05
R_Conv_1_0_6_1_1_0_1 L0_N81 L1_N13 1.6882235068e+05
R_Conv_1_0_6_1_1_1_0 L0_N82 L1_N13 1.0472083211e+05
R_Conv_1_0_6_1_1_1_1 L0_N83 L1_N13 2.1167619859e+05
R_Conv_1_0_6_1_1_2_0 L0_N84 L1_N13 1.3518319025e+05
R_Conv_1_0_6_1_1_2_1 L0_N85 L1_N13 1.4280846670e+05
R_Conv_1_0_6_1_2_0_0 L0_N136 L1_N13 1.1620759255e+05
R_Conv_1_0_6_1_2_0_1 L0_N137 L1_N13 1.6895116802e+05
R_Conv_1_0_6_1_2_1_0 L0_N138 L1_N13 1.2455043512e+06
R_Conv_1_0_6_1_2_1_1 L0_N139 L1_N13 1.1694022847e+05
R_Conv_1_0_6_1_2_2_0 L0_N140 L1_N13 1.5663616684e+06
R_Conv_1_0_6_1_2_2_1 L0_N141 L1_N13 2.1466641264e+05
*
R_Conv_1_0_7_0_0_0_0 L0_N28 L1_N14 3.0927915375e+05
R_Conv_1_0_7_0_0_0_1 L0_N29 L1_N14 3.6154472179e+05
R_Conv_1_0_7_0_0_1_0 L0_N30 L1_N14 1.2307612303e+05
R_Conv_1_0_7_0_0_1_1 L0_N31 L1_N14 1.3361401953e+06
R_Conv_1_0_7_0_0_2_0 L0_N32 L1_N14 1.1771240850e+06
R_Conv_1_0_7_0_0_2_1 L0_N33 L1_N14 1.1947062568e+05
R_Conv_1_0_7_0_1_0_0 L0_N84 L1_N14 3.4555602430e+05
R_Conv_1_0_7_0_1_0_1 L0_N85 L1_N14 1.2140655673e+05
R_Conv_1_0_7_0_1_1_0 L0_N86 L1_N14 2.0024008865e+05
R_Conv_1_0_7_0_1_1_1 L0_N87 L1_N14 1.3019124074e+05
R_Conv_1_0_7_0_1_2_0 L0_N88 L1_N14 1.1085089352e+05
R_Conv_1_0_7_0_1_2_1 L0_N89 L1_N14 2.5251460583e+05
R_Conv_1_0_7_0_2_0_0 L0_N140 L1_N14 1.1040315248e+05
R_Conv_1_0_7_0_2_0_1 L0_N141 L1_N14 1.2105931856e+05
R_Conv_1_0_7_0_2_1_0 L0_N142 L1_N14 1.0186236681e+05
R_Conv_1_0_7_0_2_1_1 L0_N143 L1_N14 3.8798345399e+05
R_Conv_1_0_7_0_2_2_0 L0_N144 L1_N14 4.4022254443e+06
R_Conv_1_0_7_0_2_2_1 L0_N145 L1_N14 1.5358515901e+05
*
R_Conv_1_0_7_1_0_0_0 L0_N28 L1_N15 1.2123709737e+05
R_Conv_1_0_7_1_0_0_1 L0_N29 L1_N15 1.0849154640e+05
R_Conv_1_0_7_1_0_1_0 L0_N30 L1_N15 2.0480317885e+05
R_Conv_1_0_7_1_0_1_1 L0_N31 L1_N15 1.6641635952e+05
R_Conv_1_0_7_1_0_2_0 L0_N32 L1_N15 1.1683261279e+06
R_Conv_1_0_7_1_0_2_1 L0_N33 L1_N15 1.1602008983e+05
R_Conv_1_0_7_1_1_0_0 L0_N84 L1_N15 1.2296662853e+05
R_Conv_1_0_7_1_1_0_1 L0_N85 L1_N15 1.6882235068e+05
R_Conv_1_0_7_1_1_1_0 L0_N86 L1_N15 1.0472083211e+05
R_Conv_1_0_7_1_1_1_1 L0_N87 L1_N15 2.1167619859e+05
R_Conv_1_0_7_1_1_2_0 L0_N88 L1_N15 1.3518319025e+05
R_Conv_1_0_7_1_1_2_1 L0_N89 L1_N15 1.4280846670e+05
R_Conv_1_0_7_1_2_0_0 L0_N140 L1_N15 1.1620759255e+05
R_Conv_1_0_7_1_2_0_1 L0_N141 L1_N15 1.6895116802e+05
R_Conv_1_0_7_1_2_1_0 L0_N142 L1_N15 1.2455043512e+06
R_Conv_1_0_7_1_2_1_1 L0_N143 L1_N15 1.1694022847e+05
R_Conv_1_0_7_1_2_2_0 L0_N144 L1_N15 1.5663616684e+06
R_Conv_1_0_7_1_2_2_1 L0_N145 L1_N15 2.1466641264e+05
*
R_Conv_1_0_8_0_0_0_0 L0_N32 L1_N16 3.0927915375e+05
R_Conv_1_0_8_0_0_0_1 L0_N33 L1_N16 3.6154472179e+05
R_Conv_1_0_8_0_0_1_0 L0_N34 L1_N16 1.2307612303e+05
R_Conv_1_0_8_0_0_1_1 L0_N35 L1_N16 1.3361401953e+06
R_Conv_1_0_8_0_0_2_0 L0_N36 L1_N16 1.1771240850e+06
R_Conv_1_0_8_0_0_2_1 L0_N37 L1_N16 1.1947062568e+05
R_Conv_1_0_8_0_1_0_0 L0_N88 L1_N16 3.4555602430e+05
R_Conv_1_0_8_0_1_0_1 L0_N89 L1_N16 1.2140655673e+05
R_Conv_1_0_8_0_1_1_0 L0_N90 L1_N16 2.0024008865e+05
R_Conv_1_0_8_0_1_1_1 L0_N91 L1_N16 1.3019124074e+05
R_Conv_1_0_8_0_1_2_0 L0_N92 L1_N16 1.1085089352e+05
R_Conv_1_0_8_0_1_2_1 L0_N93 L1_N16 2.5251460583e+05
R_Conv_1_0_8_0_2_0_0 L0_N144 L1_N16 1.1040315248e+05
R_Conv_1_0_8_0_2_0_1 L0_N145 L1_N16 1.2105931856e+05
R_Conv_1_0_8_0_2_1_0 L0_N146 L1_N16 1.0186236681e+05
R_Conv_1_0_8_0_2_1_1 L0_N147 L1_N16 3.8798345399e+05
R_Conv_1_0_8_0_2_2_0 L0_N148 L1_N16 4.4022254443e+06
R_Conv_1_0_8_0_2_2_1 L0_N149 L1_N16 1.5358515901e+05
*
R_Conv_1_0_8_1_0_0_0 L0_N32 L1_N17 1.2123709737e+05
R_Conv_1_0_8_1_0_0_1 L0_N33 L1_N17 1.0849154640e+05
R_Conv_1_0_8_1_0_1_0 L0_N34 L1_N17 2.0480317885e+05
R_Conv_1_0_8_1_0_1_1 L0_N35 L1_N17 1.6641635952e+05
R_Conv_1_0_8_1_0_2_0 L0_N36 L1_N17 1.1683261279e+06
R_Conv_1_0_8_1_0_2_1 L0_N37 L1_N17 1.1602008983e+05
R_Conv_1_0_8_1_1_0_0 L0_N88 L1_N17 1.2296662853e+05
R_Conv_1_0_8_1_1_0_1 L0_N89 L1_N17 1.6882235068e+05
R_Conv_1_0_8_1_1_1_0 L0_N90 L1_N17 1.0472083211e+05
R_Conv_1_0_8_1_1_1_1 L0_N91 L1_N17 2.1167619859e+05
R_Conv_1_0_8_1_1_2_0 L0_N92 L1_N17 1.3518319025e+05
R_Conv_1_0_8_1_1_2_1 L0_N93 L1_N17 1.4280846670e+05
R_Conv_1_0_8_1_2_0_0 L0_N144 L1_N17 1.1620759255e+05
R_Conv_1_0_8_1_2_0_1 L0_N145 L1_N17 1.6895116802e+05
R_Conv_1_0_8_1_2_1_0 L0_N146 L1_N17 1.2455043512e+06
R_Conv_1_0_8_1_2_1_1 L0_N147 L1_N17 1.1694022847e+05
R_Conv_1_0_8_1_2_2_0 L0_N148 L1_N17 1.5663616684e+06
R_Conv_1_0_8_1_2_2_1 L0_N149 L1_N17 2.1466641264e+05
*
R_Conv_1_0_9_0_0_0_0 L0_N36 L1_N18 3.0927915375e+05
R_Conv_1_0_9_0_0_0_1 L0_N37 L1_N18 3.6154472179e+05
R_Conv_1_0_9_0_0_1_0 L0_N38 L1_N18 1.2307612303e+05
R_Conv_1_0_9_0_0_1_1 L0_N39 L1_N18 1.3361401953e+06
R_Conv_1_0_9_0_0_2_0 L0_N40 L1_N18 1.1771240850e+06
R_Conv_1_0_9_0_0_2_1 L0_N41 L1_N18 1.1947062568e+05
R_Conv_1_0_9_0_1_0_0 L0_N92 L1_N18 3.4555602430e+05
R_Conv_1_0_9_0_1_0_1 L0_N93 L1_N18 1.2140655673e+05
R_Conv_1_0_9_0_1_1_0 L0_N94 L1_N18 2.0024008865e+05
R_Conv_1_0_9_0_1_1_1 L0_N95 L1_N18 1.3019124074e+05
R_Conv_1_0_9_0_1_2_0 L0_N96 L1_N18 1.1085089352e+05
R_Conv_1_0_9_0_1_2_1 L0_N97 L1_N18 2.5251460583e+05
R_Conv_1_0_9_0_2_0_0 L0_N148 L1_N18 1.1040315248e+05
R_Conv_1_0_9_0_2_0_1 L0_N149 L1_N18 1.2105931856e+05
R_Conv_1_0_9_0_2_1_0 L0_N150 L1_N18 1.0186236681e+05
R_Conv_1_0_9_0_2_1_1 L0_N151 L1_N18 3.8798345399e+05
R_Conv_1_0_9_0_2_2_0 L0_N152 L1_N18 4.4022254443e+06
R_Conv_1_0_9_0_2_2_1 L0_N153 L1_N18 1.5358515901e+05
*
R_Conv_1_0_9_1_0_0_0 L0_N36 L1_N19 1.2123709737e+05
R_Conv_1_0_9_1_0_0_1 L0_N37 L1_N19 1.0849154640e+05
R_Conv_1_0_9_1_0_1_0 L0_N38 L1_N19 2.0480317885e+05
R_Conv_1_0_9_1_0_1_1 L0_N39 L1_N19 1.6641635952e+05
R_Conv_1_0_9_1_0_2_0 L0_N40 L1_N19 1.1683261279e+06
R_Conv_1_0_9_1_0_2_1 L0_N41 L1_N19 1.1602008983e+05
R_Conv_1_0_9_1_1_0_0 L0_N92 L1_N19 1.2296662853e+05
R_Conv_1_0_9_1_1_0_1 L0_N93 L1_N19 1.6882235068e+05
R_Conv_1_0_9_1_1_1_0 L0_N94 L1_N19 1.0472083211e+05
R_Conv_1_0_9_1_1_1_1 L0_N95 L1_N19 2.1167619859e+05
R_Conv_1_0_9_1_1_2_0 L0_N96 L1_N19 1.3518319025e+05
R_Conv_1_0_9_1_1_2_1 L0_N97 L1_N19 1.4280846670e+05
R_Conv_1_0_9_1_2_0_0 L0_N148 L1_N19 1.1620759255e+05
R_Conv_1_0_9_1_2_0_1 L0_N149 L1_N19 1.6895116802e+05
R_Conv_1_0_9_1_2_1_0 L0_N150 L1_N19 1.2455043512e+06
R_Conv_1_0_9_1_2_1_1 L0_N151 L1_N19 1.1694022847e+05
R_Conv_1_0_9_1_2_2_0 L0_N152 L1_N19 1.5663616684e+06
R_Conv_1_0_9_1_2_2_1 L0_N153 L1_N19 2.1466641264e+05
*
R_Conv_1_0_10_0_0_0_0 L0_N40 L1_N20 3.0927915375e+05
R_Conv_1_0_10_0_0_0_1 L0_N41 L1_N20 3.6154472179e+05
R_Conv_1_0_10_0_0_1_0 L0_N42 L1_N20 1.2307612303e+05
R_Conv_1_0_10_0_0_1_1 L0_N43 L1_N20 1.3361401953e+06
R_Conv_1_0_10_0_0_2_0 L0_N44 L1_N20 1.1771240850e+06
R_Conv_1_0_10_0_0_2_1 L0_N45 L1_N20 1.1947062568e+05
R_Conv_1_0_10_0_1_0_0 L0_N96 L1_N20 3.4555602430e+05
R_Conv_1_0_10_0_1_0_1 L0_N97 L1_N20 1.2140655673e+05
R_Conv_1_0_10_0_1_1_0 L0_N98 L1_N20 2.0024008865e+05
R_Conv_1_0_10_0_1_1_1 L0_N99 L1_N20 1.3019124074e+05
R_Conv_1_0_10_0_1_2_0 L0_N100 L1_N20 1.1085089352e+05
R_Conv_1_0_10_0_1_2_1 L0_N101 L1_N20 2.5251460583e+05
R_Conv_1_0_10_0_2_0_0 L0_N152 L1_N20 1.1040315248e+05
R_Conv_1_0_10_0_2_0_1 L0_N153 L1_N20 1.2105931856e+05
R_Conv_1_0_10_0_2_1_0 L0_N154 L1_N20 1.0186236681e+05
R_Conv_1_0_10_0_2_1_1 L0_N155 L1_N20 3.8798345399e+05
R_Conv_1_0_10_0_2_2_0 L0_N156 L1_N20 4.4022254443e+06
R_Conv_1_0_10_0_2_2_1 L0_N157 L1_N20 1.5358515901e+05
*
R_Conv_1_0_10_1_0_0_0 L0_N40 L1_N21 1.2123709737e+05
R_Conv_1_0_10_1_0_0_1 L0_N41 L1_N21 1.0849154640e+05
R_Conv_1_0_10_1_0_1_0 L0_N42 L1_N21 2.0480317885e+05
R_Conv_1_0_10_1_0_1_1 L0_N43 L1_N21 1.6641635952e+05
R_Conv_1_0_10_1_0_2_0 L0_N44 L1_N21 1.1683261279e+06
R_Conv_1_0_10_1_0_2_1 L0_N45 L1_N21 1.1602008983e+05
R_Conv_1_0_10_1_1_0_0 L0_N96 L1_N21 1.2296662853e+05
R_Conv_1_0_10_1_1_0_1 L0_N97 L1_N21 1.6882235068e+05
R_Conv_1_0_10_1_1_1_0 L0_N98 L1_N21 1.0472083211e+05
R_Conv_1_0_10_1_1_1_1 L0_N99 L1_N21 2.1167619859e+05
R_Conv_1_0_10_1_1_2_0 L0_N100 L1_N21 1.3518319025e+05
R_Conv_1_0_10_1_1_2_1 L0_N101 L1_N21 1.4280846670e+05
R_Conv_1_0_10_1_2_0_0 L0_N152 L1_N21 1.1620759255e+05
R_Conv_1_0_10_1_2_0_1 L0_N153 L1_N21 1.6895116802e+05
R_Conv_1_0_10_1_2_1_0 L0_N154 L1_N21 1.2455043512e+06
R_Conv_1_0_10_1_2_1_1 L0_N155 L1_N21 1.1694022847e+05
R_Conv_1_0_10_1_2_2_0 L0_N156 L1_N21 1.5663616684e+06
R_Conv_1_0_10_1_2_2_1 L0_N157 L1_N21 2.1466641264e+05
*
R_Conv_1_0_11_0_0_0_0 L0_N44 L1_N22 3.0927915375e+05
R_Conv_1_0_11_0_0_0_1 L0_N45 L1_N22 3.6154472179e+05
R_Conv_1_0_11_0_0_1_0 L0_N46 L1_N22 1.2307612303e+05
R_Conv_1_0_11_0_0_1_1 L0_N47 L1_N22 1.3361401953e+06
R_Conv_1_0_11_0_0_2_0 L0_N48 L1_N22 1.1771240850e+06
R_Conv_1_0_11_0_0_2_1 L0_N49 L1_N22 1.1947062568e+05
R_Conv_1_0_11_0_1_0_0 L0_N100 L1_N22 3.4555602430e+05
R_Conv_1_0_11_0_1_0_1 L0_N101 L1_N22 1.2140655673e+05
R_Conv_1_0_11_0_1_1_0 L0_N102 L1_N22 2.0024008865e+05
R_Conv_1_0_11_0_1_1_1 L0_N103 L1_N22 1.3019124074e+05
R_Conv_1_0_11_0_1_2_0 L0_N104 L1_N22 1.1085089352e+05
R_Conv_1_0_11_0_1_2_1 L0_N105 L1_N22 2.5251460583e+05
R_Conv_1_0_11_0_2_0_0 L0_N156 L1_N22 1.1040315248e+05
R_Conv_1_0_11_0_2_0_1 L0_N157 L1_N22 1.2105931856e+05
R_Conv_1_0_11_0_2_1_0 L0_N158 L1_N22 1.0186236681e+05
R_Conv_1_0_11_0_2_1_1 L0_N159 L1_N22 3.8798345399e+05
R_Conv_1_0_11_0_2_2_0 L0_N160 L1_N22 4.4022254443e+06
R_Conv_1_0_11_0_2_2_1 L0_N161 L1_N22 1.5358515901e+05
*
R_Conv_1_0_11_1_0_0_0 L0_N44 L1_N23 1.2123709737e+05
R_Conv_1_0_11_1_0_0_1 L0_N45 L1_N23 1.0849154640e+05
R_Conv_1_0_11_1_0_1_0 L0_N46 L1_N23 2.0480317885e+05
R_Conv_1_0_11_1_0_1_1 L0_N47 L1_N23 1.6641635952e+05
R_Conv_1_0_11_1_0_2_0 L0_N48 L1_N23 1.1683261279e+06
R_Conv_1_0_11_1_0_2_1 L0_N49 L1_N23 1.1602008983e+05
R_Conv_1_0_11_1_1_0_0 L0_N100 L1_N23 1.2296662853e+05
R_Conv_1_0_11_1_1_0_1 L0_N101 L1_N23 1.6882235068e+05
R_Conv_1_0_11_1_1_1_0 L0_N102 L1_N23 1.0472083211e+05
R_Conv_1_0_11_1_1_1_1 L0_N103 L1_N23 2.1167619859e+05
R_Conv_1_0_11_1_1_2_0 L0_N104 L1_N23 1.3518319025e+05
R_Conv_1_0_11_1_1_2_1 L0_N105 L1_N23 1.4280846670e+05
R_Conv_1_0_11_1_2_0_0 L0_N156 L1_N23 1.1620759255e+05
R_Conv_1_0_11_1_2_0_1 L0_N157 L1_N23 1.6895116802e+05
R_Conv_1_0_11_1_2_1_0 L0_N158 L1_N23 1.2455043512e+06
R_Conv_1_0_11_1_2_1_1 L0_N159 L1_N23 1.1694022847e+05
R_Conv_1_0_11_1_2_2_0 L0_N160 L1_N23 1.5663616684e+06
R_Conv_1_0_11_1_2_2_1 L0_N161 L1_N23 2.1466641264e+05
*
R_Conv_1_0_12_0_0_0_0 L0_N48 L1_N24 3.0927915375e+05
R_Conv_1_0_12_0_0_0_1 L0_N49 L1_N24 3.6154472179e+05
R_Conv_1_0_12_0_0_1_0 L0_N50 L1_N24 1.2307612303e+05
R_Conv_1_0_12_0_0_1_1 L0_N51 L1_N24 1.3361401953e+06
R_Conv_1_0_12_0_0_2_0 L0_N52 L1_N24 1.1771240850e+06
R_Conv_1_0_12_0_0_2_1 L0_N53 L1_N24 1.1947062568e+05
R_Conv_1_0_12_0_1_0_0 L0_N104 L1_N24 3.4555602430e+05
R_Conv_1_0_12_0_1_0_1 L0_N105 L1_N24 1.2140655673e+05
R_Conv_1_0_12_0_1_1_0 L0_N106 L1_N24 2.0024008865e+05
R_Conv_1_0_12_0_1_1_1 L0_N107 L1_N24 1.3019124074e+05
R_Conv_1_0_12_0_1_2_0 L0_N108 L1_N24 1.1085089352e+05
R_Conv_1_0_12_0_1_2_1 L0_N109 L1_N24 2.5251460583e+05
R_Conv_1_0_12_0_2_0_0 L0_N160 L1_N24 1.1040315248e+05
R_Conv_1_0_12_0_2_0_1 L0_N161 L1_N24 1.2105931856e+05
R_Conv_1_0_12_0_2_1_0 L0_N162 L1_N24 1.0186236681e+05
R_Conv_1_0_12_0_2_1_1 L0_N163 L1_N24 3.8798345399e+05
R_Conv_1_0_12_0_2_2_0 L0_N164 L1_N24 4.4022254443e+06
R_Conv_1_0_12_0_2_2_1 L0_N165 L1_N24 1.5358515901e+05
*
R_Conv_1_0_12_1_0_0_0 L0_N48 L1_N25 1.2123709737e+05
R_Conv_1_0_12_1_0_0_1 L0_N49 L1_N25 1.0849154640e+05
R_Conv_1_0_12_1_0_1_0 L0_N50 L1_N25 2.0480317885e+05
R_Conv_1_0_12_1_0_1_1 L0_N51 L1_N25 1.6641635952e+05
R_Conv_1_0_12_1_0_2_0 L0_N52 L1_N25 1.1683261279e+06
R_Conv_1_0_12_1_0_2_1 L0_N53 L1_N25 1.1602008983e+05
R_Conv_1_0_12_1_1_0_0 L0_N104 L1_N25 1.2296662853e+05
R_Conv_1_0_12_1_1_0_1 L0_N105 L1_N25 1.6882235068e+05
R_Conv_1_0_12_1_1_1_0 L0_N106 L1_N25 1.0472083211e+05
R_Conv_1_0_12_1_1_1_1 L0_N107 L1_N25 2.1167619859e+05
R_Conv_1_0_12_1_1_2_0 L0_N108 L1_N25 1.3518319025e+05
R_Conv_1_0_12_1_1_2_1 L0_N109 L1_N25 1.4280846670e+05
R_Conv_1_0_12_1_2_0_0 L0_N160 L1_N25 1.1620759255e+05
R_Conv_1_0_12_1_2_0_1 L0_N161 L1_N25 1.6895116802e+05
R_Conv_1_0_12_1_2_1_0 L0_N162 L1_N25 1.2455043512e+06
R_Conv_1_0_12_1_2_1_1 L0_N163 L1_N25 1.1694022847e+05
R_Conv_1_0_12_1_2_2_0 L0_N164 L1_N25 1.5663616684e+06
R_Conv_1_0_12_1_2_2_1 L0_N165 L1_N25 2.1466641264e+05
*
R_Conv_1_1_0_0_0_0_0 L0_N112 L1_N26 3.0927915375e+05
R_Conv_1_1_0_0_0_0_1 L0_N113 L1_N26 3.6154472179e+05
R_Conv_1_1_0_0_0_1_0 L0_N114 L1_N26 1.2307612303e+05
R_Conv_1_1_0_0_0_1_1 L0_N115 L1_N26 1.3361401953e+06
R_Conv_1_1_0_0_0_2_0 L0_N116 L1_N26 1.1771240850e+06
R_Conv_1_1_0_0_0_2_1 L0_N117 L1_N26 1.1947062568e+05
R_Conv_1_1_0_0_1_0_0 L0_N168 L1_N26 3.4555602430e+05
R_Conv_1_1_0_0_1_0_1 L0_N169 L1_N26 1.2140655673e+05
R_Conv_1_1_0_0_1_1_0 L0_N170 L1_N26 2.0024008865e+05
R_Conv_1_1_0_0_1_1_1 L0_N171 L1_N26 1.3019124074e+05
R_Conv_1_1_0_0_1_2_0 L0_N172 L1_N26 1.1085089352e+05
R_Conv_1_1_0_0_1_2_1 L0_N173 L1_N26 2.5251460583e+05
R_Conv_1_1_0_0_2_0_0 L0_N224 L1_N26 1.1040315248e+05
R_Conv_1_1_0_0_2_0_1 L0_N225 L1_N26 1.2105931856e+05
R_Conv_1_1_0_0_2_1_0 L0_N226 L1_N26 1.0186236681e+05
R_Conv_1_1_0_0_2_1_1 L0_N227 L1_N26 3.8798345399e+05
R_Conv_1_1_0_0_2_2_0 L0_N228 L1_N26 4.4022254443e+06
R_Conv_1_1_0_0_2_2_1 L0_N229 L1_N26 1.5358515901e+05
*
R_Conv_1_1_0_1_0_0_0 L0_N112 L1_N27 1.2123709737e+05
R_Conv_1_1_0_1_0_0_1 L0_N113 L1_N27 1.0849154640e+05
R_Conv_1_1_0_1_0_1_0 L0_N114 L1_N27 2.0480317885e+05
R_Conv_1_1_0_1_0_1_1 L0_N115 L1_N27 1.6641635952e+05
R_Conv_1_1_0_1_0_2_0 L0_N116 L1_N27 1.1683261279e+06
R_Conv_1_1_0_1_0_2_1 L0_N117 L1_N27 1.1602008983e+05
R_Conv_1_1_0_1_1_0_0 L0_N168 L1_N27 1.2296662853e+05
R_Conv_1_1_0_1_1_0_1 L0_N169 L1_N27 1.6882235068e+05
R_Conv_1_1_0_1_1_1_0 L0_N170 L1_N27 1.0472083211e+05
R_Conv_1_1_0_1_1_1_1 L0_N171 L1_N27 2.1167619859e+05
R_Conv_1_1_0_1_1_2_0 L0_N172 L1_N27 1.3518319025e+05
R_Conv_1_1_0_1_1_2_1 L0_N173 L1_N27 1.4280846670e+05
R_Conv_1_1_0_1_2_0_0 L0_N224 L1_N27 1.1620759255e+05
R_Conv_1_1_0_1_2_0_1 L0_N225 L1_N27 1.6895116802e+05
R_Conv_1_1_0_1_2_1_0 L0_N226 L1_N27 1.2455043512e+06
R_Conv_1_1_0_1_2_1_1 L0_N227 L1_N27 1.1694022847e+05
R_Conv_1_1_0_1_2_2_0 L0_N228 L1_N27 1.5663616684e+06
R_Conv_1_1_0_1_2_2_1 L0_N229 L1_N27 2.1466641264e+05
*
R_Conv_1_1_1_0_0_0_0 L0_N116 L1_N28 3.0927915375e+05
R_Conv_1_1_1_0_0_0_1 L0_N117 L1_N28 3.6154472179e+05
R_Conv_1_1_1_0_0_1_0 L0_N118 L1_N28 1.2307612303e+05
R_Conv_1_1_1_0_0_1_1 L0_N119 L1_N28 1.3361401953e+06
R_Conv_1_1_1_0_0_2_0 L0_N120 L1_N28 1.1771240850e+06
R_Conv_1_1_1_0_0_2_1 L0_N121 L1_N28 1.1947062568e+05
R_Conv_1_1_1_0_1_0_0 L0_N172 L1_N28 3.4555602430e+05
R_Conv_1_1_1_0_1_0_1 L0_N173 L1_N28 1.2140655673e+05
R_Conv_1_1_1_0_1_1_0 L0_N174 L1_N28 2.0024008865e+05
R_Conv_1_1_1_0_1_1_1 L0_N175 L1_N28 1.3019124074e+05
R_Conv_1_1_1_0_1_2_0 L0_N176 L1_N28 1.1085089352e+05
R_Conv_1_1_1_0_1_2_1 L0_N177 L1_N28 2.5251460583e+05
R_Conv_1_1_1_0_2_0_0 L0_N228 L1_N28 1.1040315248e+05
R_Conv_1_1_1_0_2_0_1 L0_N229 L1_N28 1.2105931856e+05
R_Conv_1_1_1_0_2_1_0 L0_N230 L1_N28 1.0186236681e+05
R_Conv_1_1_1_0_2_1_1 L0_N231 L1_N28 3.8798345399e+05
R_Conv_1_1_1_0_2_2_0 L0_N232 L1_N28 4.4022254443e+06
R_Conv_1_1_1_0_2_2_1 L0_N233 L1_N28 1.5358515901e+05
*
R_Conv_1_1_1_1_0_0_0 L0_N116 L1_N29 1.2123709737e+05
R_Conv_1_1_1_1_0_0_1 L0_N117 L1_N29 1.0849154640e+05
R_Conv_1_1_1_1_0_1_0 L0_N118 L1_N29 2.0480317885e+05
R_Conv_1_1_1_1_0_1_1 L0_N119 L1_N29 1.6641635952e+05
R_Conv_1_1_1_1_0_2_0 L0_N120 L1_N29 1.1683261279e+06
R_Conv_1_1_1_1_0_2_1 L0_N121 L1_N29 1.1602008983e+05
R_Conv_1_1_1_1_1_0_0 L0_N172 L1_N29 1.2296662853e+05
R_Conv_1_1_1_1_1_0_1 L0_N173 L1_N29 1.6882235068e+05
R_Conv_1_1_1_1_1_1_0 L0_N174 L1_N29 1.0472083211e+05
R_Conv_1_1_1_1_1_1_1 L0_N175 L1_N29 2.1167619859e+05
R_Conv_1_1_1_1_1_2_0 L0_N176 L1_N29 1.3518319025e+05
R_Conv_1_1_1_1_1_2_1 L0_N177 L1_N29 1.4280846670e+05
R_Conv_1_1_1_1_2_0_0 L0_N228 L1_N29 1.1620759255e+05
R_Conv_1_1_1_1_2_0_1 L0_N229 L1_N29 1.6895116802e+05
R_Conv_1_1_1_1_2_1_0 L0_N230 L1_N29 1.2455043512e+06
R_Conv_1_1_1_1_2_1_1 L0_N231 L1_N29 1.1694022847e+05
R_Conv_1_1_1_1_2_2_0 L0_N232 L1_N29 1.5663616684e+06
R_Conv_1_1_1_1_2_2_1 L0_N233 L1_N29 2.1466641264e+05
*
R_Conv_1_1_2_0_0_0_0 L0_N120 L1_N30 3.0927915375e+05
R_Conv_1_1_2_0_0_0_1 L0_N121 L1_N30 3.6154472179e+05
R_Conv_1_1_2_0_0_1_0 L0_N122 L1_N30 1.2307612303e+05
R_Conv_1_1_2_0_0_1_1 L0_N123 L1_N30 1.3361401953e+06
R_Conv_1_1_2_0_0_2_0 L0_N124 L1_N30 1.1771240850e+06
R_Conv_1_1_2_0_0_2_1 L0_N125 L1_N30 1.1947062568e+05
R_Conv_1_1_2_0_1_0_0 L0_N176 L1_N30 3.4555602430e+05
R_Conv_1_1_2_0_1_0_1 L0_N177 L1_N30 1.2140655673e+05
R_Conv_1_1_2_0_1_1_0 L0_N178 L1_N30 2.0024008865e+05
R_Conv_1_1_2_0_1_1_1 L0_N179 L1_N30 1.3019124074e+05
R_Conv_1_1_2_0_1_2_0 L0_N180 L1_N30 1.1085089352e+05
R_Conv_1_1_2_0_1_2_1 L0_N181 L1_N30 2.5251460583e+05
R_Conv_1_1_2_0_2_0_0 L0_N232 L1_N30 1.1040315248e+05
R_Conv_1_1_2_0_2_0_1 L0_N233 L1_N30 1.2105931856e+05
R_Conv_1_1_2_0_2_1_0 L0_N234 L1_N30 1.0186236681e+05
R_Conv_1_1_2_0_2_1_1 L0_N235 L1_N30 3.8798345399e+05
R_Conv_1_1_2_0_2_2_0 L0_N236 L1_N30 4.4022254443e+06
R_Conv_1_1_2_0_2_2_1 L0_N237 L1_N30 1.5358515901e+05
*
R_Conv_1_1_2_1_0_0_0 L0_N120 L1_N31 1.2123709737e+05
R_Conv_1_1_2_1_0_0_1 L0_N121 L1_N31 1.0849154640e+05
R_Conv_1_1_2_1_0_1_0 L0_N122 L1_N31 2.0480317885e+05
R_Conv_1_1_2_1_0_1_1 L0_N123 L1_N31 1.6641635952e+05
R_Conv_1_1_2_1_0_2_0 L0_N124 L1_N31 1.1683261279e+06
R_Conv_1_1_2_1_0_2_1 L0_N125 L1_N31 1.1602008983e+05
R_Conv_1_1_2_1_1_0_0 L0_N176 L1_N31 1.2296662853e+05
R_Conv_1_1_2_1_1_0_1 L0_N177 L1_N31 1.6882235068e+05
R_Conv_1_1_2_1_1_1_0 L0_N178 L1_N31 1.0472083211e+05
R_Conv_1_1_2_1_1_1_1 L0_N179 L1_N31 2.1167619859e+05
R_Conv_1_1_2_1_1_2_0 L0_N180 L1_N31 1.3518319025e+05
R_Conv_1_1_2_1_1_2_1 L0_N181 L1_N31 1.4280846670e+05
R_Conv_1_1_2_1_2_0_0 L0_N232 L1_N31 1.1620759255e+05
R_Conv_1_1_2_1_2_0_1 L0_N233 L1_N31 1.6895116802e+05
R_Conv_1_1_2_1_2_1_0 L0_N234 L1_N31 1.2455043512e+06
R_Conv_1_1_2_1_2_1_1 L0_N235 L1_N31 1.1694022847e+05
R_Conv_1_1_2_1_2_2_0 L0_N236 L1_N31 1.5663616684e+06
R_Conv_1_1_2_1_2_2_1 L0_N237 L1_N31 2.1466641264e+05
*
R_Conv_1_1_3_0_0_0_0 L0_N124 L1_N32 3.0927915375e+05
R_Conv_1_1_3_0_0_0_1 L0_N125 L1_N32 3.6154472179e+05
R_Conv_1_1_3_0_0_1_0 L0_N126 L1_N32 1.2307612303e+05
R_Conv_1_1_3_0_0_1_1 L0_N127 L1_N32 1.3361401953e+06
R_Conv_1_1_3_0_0_2_0 L0_N128 L1_N32 1.1771240850e+06
R_Conv_1_1_3_0_0_2_1 L0_N129 L1_N32 1.1947062568e+05
R_Conv_1_1_3_0_1_0_0 L0_N180 L1_N32 3.4555602430e+05
R_Conv_1_1_3_0_1_0_1 L0_N181 L1_N32 1.2140655673e+05
R_Conv_1_1_3_0_1_1_0 L0_N182 L1_N32 2.0024008865e+05
R_Conv_1_1_3_0_1_1_1 L0_N183 L1_N32 1.3019124074e+05
R_Conv_1_1_3_0_1_2_0 L0_N184 L1_N32 1.1085089352e+05
R_Conv_1_1_3_0_1_2_1 L0_N185 L1_N32 2.5251460583e+05
R_Conv_1_1_3_0_2_0_0 L0_N236 L1_N32 1.1040315248e+05
R_Conv_1_1_3_0_2_0_1 L0_N237 L1_N32 1.2105931856e+05
R_Conv_1_1_3_0_2_1_0 L0_N238 L1_N32 1.0186236681e+05
R_Conv_1_1_3_0_2_1_1 L0_N239 L1_N32 3.8798345399e+05
R_Conv_1_1_3_0_2_2_0 L0_N240 L1_N32 4.4022254443e+06
R_Conv_1_1_3_0_2_2_1 L0_N241 L1_N32 1.5358515901e+05
*
R_Conv_1_1_3_1_0_0_0 L0_N124 L1_N33 1.2123709737e+05
R_Conv_1_1_3_1_0_0_1 L0_N125 L1_N33 1.0849154640e+05
R_Conv_1_1_3_1_0_1_0 L0_N126 L1_N33 2.0480317885e+05
R_Conv_1_1_3_1_0_1_1 L0_N127 L1_N33 1.6641635952e+05
R_Conv_1_1_3_1_0_2_0 L0_N128 L1_N33 1.1683261279e+06
R_Conv_1_1_3_1_0_2_1 L0_N129 L1_N33 1.1602008983e+05
R_Conv_1_1_3_1_1_0_0 L0_N180 L1_N33 1.2296662853e+05
R_Conv_1_1_3_1_1_0_1 L0_N181 L1_N33 1.6882235068e+05
R_Conv_1_1_3_1_1_1_0 L0_N182 L1_N33 1.0472083211e+05
R_Conv_1_1_3_1_1_1_1 L0_N183 L1_N33 2.1167619859e+05
R_Conv_1_1_3_1_1_2_0 L0_N184 L1_N33 1.3518319025e+05
R_Conv_1_1_3_1_1_2_1 L0_N185 L1_N33 1.4280846670e+05
R_Conv_1_1_3_1_2_0_0 L0_N236 L1_N33 1.1620759255e+05
R_Conv_1_1_3_1_2_0_1 L0_N237 L1_N33 1.6895116802e+05
R_Conv_1_1_3_1_2_1_0 L0_N238 L1_N33 1.2455043512e+06
R_Conv_1_1_3_1_2_1_1 L0_N239 L1_N33 1.1694022847e+05
R_Conv_1_1_3_1_2_2_0 L0_N240 L1_N33 1.5663616684e+06
R_Conv_1_1_3_1_2_2_1 L0_N241 L1_N33 2.1466641264e+05
*
R_Conv_1_1_4_0_0_0_0 L0_N128 L1_N34 3.0927915375e+05
R_Conv_1_1_4_0_0_0_1 L0_N129 L1_N34 3.6154472179e+05
R_Conv_1_1_4_0_0_1_0 L0_N130 L1_N34 1.2307612303e+05
R_Conv_1_1_4_0_0_1_1 L0_N131 L1_N34 1.3361401953e+06
R_Conv_1_1_4_0_0_2_0 L0_N132 L1_N34 1.1771240850e+06
R_Conv_1_1_4_0_0_2_1 L0_N133 L1_N34 1.1947062568e+05
R_Conv_1_1_4_0_1_0_0 L0_N184 L1_N34 3.4555602430e+05
R_Conv_1_1_4_0_1_0_1 L0_N185 L1_N34 1.2140655673e+05
R_Conv_1_1_4_0_1_1_0 L0_N186 L1_N34 2.0024008865e+05
R_Conv_1_1_4_0_1_1_1 L0_N187 L1_N34 1.3019124074e+05
R_Conv_1_1_4_0_1_2_0 L0_N188 L1_N34 1.1085089352e+05
R_Conv_1_1_4_0_1_2_1 L0_N189 L1_N34 2.5251460583e+05
R_Conv_1_1_4_0_2_0_0 L0_N240 L1_N34 1.1040315248e+05
R_Conv_1_1_4_0_2_0_1 L0_N241 L1_N34 1.2105931856e+05
R_Conv_1_1_4_0_2_1_0 L0_N242 L1_N34 1.0186236681e+05
R_Conv_1_1_4_0_2_1_1 L0_N243 L1_N34 3.8798345399e+05
R_Conv_1_1_4_0_2_2_0 L0_N244 L1_N34 4.4022254443e+06
R_Conv_1_1_4_0_2_2_1 L0_N245 L1_N34 1.5358515901e+05
*
R_Conv_1_1_4_1_0_0_0 L0_N128 L1_N35 1.2123709737e+05
R_Conv_1_1_4_1_0_0_1 L0_N129 L1_N35 1.0849154640e+05
R_Conv_1_1_4_1_0_1_0 L0_N130 L1_N35 2.0480317885e+05
R_Conv_1_1_4_1_0_1_1 L0_N131 L1_N35 1.6641635952e+05
R_Conv_1_1_4_1_0_2_0 L0_N132 L1_N35 1.1683261279e+06
R_Conv_1_1_4_1_0_2_1 L0_N133 L1_N35 1.1602008983e+05
R_Conv_1_1_4_1_1_0_0 L0_N184 L1_N35 1.2296662853e+05
R_Conv_1_1_4_1_1_0_1 L0_N185 L1_N35 1.6882235068e+05
R_Conv_1_1_4_1_1_1_0 L0_N186 L1_N35 1.0472083211e+05
R_Conv_1_1_4_1_1_1_1 L0_N187 L1_N35 2.1167619859e+05
R_Conv_1_1_4_1_1_2_0 L0_N188 L1_N35 1.3518319025e+05
R_Conv_1_1_4_1_1_2_1 L0_N189 L1_N35 1.4280846670e+05
R_Conv_1_1_4_1_2_0_0 L0_N240 L1_N35 1.1620759255e+05
R_Conv_1_1_4_1_2_0_1 L0_N241 L1_N35 1.6895116802e+05
R_Conv_1_1_4_1_2_1_0 L0_N242 L1_N35 1.2455043512e+06
R_Conv_1_1_4_1_2_1_1 L0_N243 L1_N35 1.1694022847e+05
R_Conv_1_1_4_1_2_2_0 L0_N244 L1_N35 1.5663616684e+06
R_Conv_1_1_4_1_2_2_1 L0_N245 L1_N35 2.1466641264e+05
*
R_Conv_1_1_5_0_0_0_0 L0_N132 L1_N36 3.0927915375e+05
R_Conv_1_1_5_0_0_0_1 L0_N133 L1_N36 3.6154472179e+05
R_Conv_1_1_5_0_0_1_0 L0_N134 L1_N36 1.2307612303e+05
R_Conv_1_1_5_0_0_1_1 L0_N135 L1_N36 1.3361401953e+06
R_Conv_1_1_5_0_0_2_0 L0_N136 L1_N36 1.1771240850e+06
R_Conv_1_1_5_0_0_2_1 L0_N137 L1_N36 1.1947062568e+05
R_Conv_1_1_5_0_1_0_0 L0_N188 L1_N36 3.4555602430e+05
R_Conv_1_1_5_0_1_0_1 L0_N189 L1_N36 1.2140655673e+05
R_Conv_1_1_5_0_1_1_0 L0_N190 L1_N36 2.0024008865e+05
R_Conv_1_1_5_0_1_1_1 L0_N191 L1_N36 1.3019124074e+05
R_Conv_1_1_5_0_1_2_0 L0_N192 L1_N36 1.1085089352e+05
R_Conv_1_1_5_0_1_2_1 L0_N193 L1_N36 2.5251460583e+05
R_Conv_1_1_5_0_2_0_0 L0_N244 L1_N36 1.1040315248e+05
R_Conv_1_1_5_0_2_0_1 L0_N245 L1_N36 1.2105931856e+05
R_Conv_1_1_5_0_2_1_0 L0_N246 L1_N36 1.0186236681e+05
R_Conv_1_1_5_0_2_1_1 L0_N247 L1_N36 3.8798345399e+05
R_Conv_1_1_5_0_2_2_0 L0_N248 L1_N36 4.4022254443e+06
R_Conv_1_1_5_0_2_2_1 L0_N249 L1_N36 1.5358515901e+05
*
R_Conv_1_1_5_1_0_0_0 L0_N132 L1_N37 1.2123709737e+05
R_Conv_1_1_5_1_0_0_1 L0_N133 L1_N37 1.0849154640e+05
R_Conv_1_1_5_1_0_1_0 L0_N134 L1_N37 2.0480317885e+05
R_Conv_1_1_5_1_0_1_1 L0_N135 L1_N37 1.6641635952e+05
R_Conv_1_1_5_1_0_2_0 L0_N136 L1_N37 1.1683261279e+06
R_Conv_1_1_5_1_0_2_1 L0_N137 L1_N37 1.1602008983e+05
R_Conv_1_1_5_1_1_0_0 L0_N188 L1_N37 1.2296662853e+05
R_Conv_1_1_5_1_1_0_1 L0_N189 L1_N37 1.6882235068e+05
R_Conv_1_1_5_1_1_1_0 L0_N190 L1_N37 1.0472083211e+05
R_Conv_1_1_5_1_1_1_1 L0_N191 L1_N37 2.1167619859e+05
R_Conv_1_1_5_1_1_2_0 L0_N192 L1_N37 1.3518319025e+05
R_Conv_1_1_5_1_1_2_1 L0_N193 L1_N37 1.4280846670e+05
R_Conv_1_1_5_1_2_0_0 L0_N244 L1_N37 1.1620759255e+05
R_Conv_1_1_5_1_2_0_1 L0_N245 L1_N37 1.6895116802e+05
R_Conv_1_1_5_1_2_1_0 L0_N246 L1_N37 1.2455043512e+06
R_Conv_1_1_5_1_2_1_1 L0_N247 L1_N37 1.1694022847e+05
R_Conv_1_1_5_1_2_2_0 L0_N248 L1_N37 1.5663616684e+06
R_Conv_1_1_5_1_2_2_1 L0_N249 L1_N37 2.1466641264e+05
*
R_Conv_1_1_6_0_0_0_0 L0_N136 L1_N38 3.0927915375e+05
R_Conv_1_1_6_0_0_0_1 L0_N137 L1_N38 3.6154472179e+05
R_Conv_1_1_6_0_0_1_0 L0_N138 L1_N38 1.2307612303e+05
R_Conv_1_1_6_0_0_1_1 L0_N139 L1_N38 1.3361401953e+06
R_Conv_1_1_6_0_0_2_0 L0_N140 L1_N38 1.1771240850e+06
R_Conv_1_1_6_0_0_2_1 L0_N141 L1_N38 1.1947062568e+05
R_Conv_1_1_6_0_1_0_0 L0_N192 L1_N38 3.4555602430e+05
R_Conv_1_1_6_0_1_0_1 L0_N193 L1_N38 1.2140655673e+05
R_Conv_1_1_6_0_1_1_0 L0_N194 L1_N38 2.0024008865e+05
R_Conv_1_1_6_0_1_1_1 L0_N195 L1_N38 1.3019124074e+05
R_Conv_1_1_6_0_1_2_0 L0_N196 L1_N38 1.1085089352e+05
R_Conv_1_1_6_0_1_2_1 L0_N197 L1_N38 2.5251460583e+05
R_Conv_1_1_6_0_2_0_0 L0_N248 L1_N38 1.1040315248e+05
R_Conv_1_1_6_0_2_0_1 L0_N249 L1_N38 1.2105931856e+05
R_Conv_1_1_6_0_2_1_0 L0_N250 L1_N38 1.0186236681e+05
R_Conv_1_1_6_0_2_1_1 L0_N251 L1_N38 3.8798345399e+05
R_Conv_1_1_6_0_2_2_0 L0_N252 L1_N38 4.4022254443e+06
R_Conv_1_1_6_0_2_2_1 L0_N253 L1_N38 1.5358515901e+05
*
R_Conv_1_1_6_1_0_0_0 L0_N136 L1_N39 1.2123709737e+05
R_Conv_1_1_6_1_0_0_1 L0_N137 L1_N39 1.0849154640e+05
R_Conv_1_1_6_1_0_1_0 L0_N138 L1_N39 2.0480317885e+05
R_Conv_1_1_6_1_0_1_1 L0_N139 L1_N39 1.6641635952e+05
R_Conv_1_1_6_1_0_2_0 L0_N140 L1_N39 1.1683261279e+06
R_Conv_1_1_6_1_0_2_1 L0_N141 L1_N39 1.1602008983e+05
R_Conv_1_1_6_1_1_0_0 L0_N192 L1_N39 1.2296662853e+05
R_Conv_1_1_6_1_1_0_1 L0_N193 L1_N39 1.6882235068e+05
R_Conv_1_1_6_1_1_1_0 L0_N194 L1_N39 1.0472083211e+05
R_Conv_1_1_6_1_1_1_1 L0_N195 L1_N39 2.1167619859e+05
R_Conv_1_1_6_1_1_2_0 L0_N196 L1_N39 1.3518319025e+05
R_Conv_1_1_6_1_1_2_1 L0_N197 L1_N39 1.4280846670e+05
R_Conv_1_1_6_1_2_0_0 L0_N248 L1_N39 1.1620759255e+05
R_Conv_1_1_6_1_2_0_1 L0_N249 L1_N39 1.6895116802e+05
R_Conv_1_1_6_1_2_1_0 L0_N250 L1_N39 1.2455043512e+06
R_Conv_1_1_6_1_2_1_1 L0_N251 L1_N39 1.1694022847e+05
R_Conv_1_1_6_1_2_2_0 L0_N252 L1_N39 1.5663616684e+06
R_Conv_1_1_6_1_2_2_1 L0_N253 L1_N39 2.1466641264e+05
*
R_Conv_1_1_7_0_0_0_0 L0_N140 L1_N40 3.0927915375e+05
R_Conv_1_1_7_0_0_0_1 L0_N141 L1_N40 3.6154472179e+05
R_Conv_1_1_7_0_0_1_0 L0_N142 L1_N40 1.2307612303e+05
R_Conv_1_1_7_0_0_1_1 L0_N143 L1_N40 1.3361401953e+06
R_Conv_1_1_7_0_0_2_0 L0_N144 L1_N40 1.1771240850e+06
R_Conv_1_1_7_0_0_2_1 L0_N145 L1_N40 1.1947062568e+05
R_Conv_1_1_7_0_1_0_0 L0_N196 L1_N40 3.4555602430e+05
R_Conv_1_1_7_0_1_0_1 L0_N197 L1_N40 1.2140655673e+05
R_Conv_1_1_7_0_1_1_0 L0_N198 L1_N40 2.0024008865e+05
R_Conv_1_1_7_0_1_1_1 L0_N199 L1_N40 1.3019124074e+05
R_Conv_1_1_7_0_1_2_0 L0_N200 L1_N40 1.1085089352e+05
R_Conv_1_1_7_0_1_2_1 L0_N201 L1_N40 2.5251460583e+05
R_Conv_1_1_7_0_2_0_0 L0_N252 L1_N40 1.1040315248e+05
R_Conv_1_1_7_0_2_0_1 L0_N253 L1_N40 1.2105931856e+05
R_Conv_1_1_7_0_2_1_0 L0_N254 L1_N40 1.0186236681e+05
R_Conv_1_1_7_0_2_1_1 L0_N255 L1_N40 3.8798345399e+05
R_Conv_1_1_7_0_2_2_0 L0_N256 L1_N40 4.4022254443e+06
R_Conv_1_1_7_0_2_2_1 L0_N257 L1_N40 1.5358515901e+05
*
R_Conv_1_1_7_1_0_0_0 L0_N140 L1_N41 1.2123709737e+05
R_Conv_1_1_7_1_0_0_1 L0_N141 L1_N41 1.0849154640e+05
R_Conv_1_1_7_1_0_1_0 L0_N142 L1_N41 2.0480317885e+05
R_Conv_1_1_7_1_0_1_1 L0_N143 L1_N41 1.6641635952e+05
R_Conv_1_1_7_1_0_2_0 L0_N144 L1_N41 1.1683261279e+06
R_Conv_1_1_7_1_0_2_1 L0_N145 L1_N41 1.1602008983e+05
R_Conv_1_1_7_1_1_0_0 L0_N196 L1_N41 1.2296662853e+05
R_Conv_1_1_7_1_1_0_1 L0_N197 L1_N41 1.6882235068e+05
R_Conv_1_1_7_1_1_1_0 L0_N198 L1_N41 1.0472083211e+05
R_Conv_1_1_7_1_1_1_1 L0_N199 L1_N41 2.1167619859e+05
R_Conv_1_1_7_1_1_2_0 L0_N200 L1_N41 1.3518319025e+05
R_Conv_1_1_7_1_1_2_1 L0_N201 L1_N41 1.4280846670e+05
R_Conv_1_1_7_1_2_0_0 L0_N252 L1_N41 1.1620759255e+05
R_Conv_1_1_7_1_2_0_1 L0_N253 L1_N41 1.6895116802e+05
R_Conv_1_1_7_1_2_1_0 L0_N254 L1_N41 1.2455043512e+06
R_Conv_1_1_7_1_2_1_1 L0_N255 L1_N41 1.1694022847e+05
R_Conv_1_1_7_1_2_2_0 L0_N256 L1_N41 1.5663616684e+06
R_Conv_1_1_7_1_2_2_1 L0_N257 L1_N41 2.1466641264e+05
*
R_Conv_1_1_8_0_0_0_0 L0_N144 L1_N42 3.0927915375e+05
R_Conv_1_1_8_0_0_0_1 L0_N145 L1_N42 3.6154472179e+05
R_Conv_1_1_8_0_0_1_0 L0_N146 L1_N42 1.2307612303e+05
R_Conv_1_1_8_0_0_1_1 L0_N147 L1_N42 1.3361401953e+06
R_Conv_1_1_8_0_0_2_0 L0_N148 L1_N42 1.1771240850e+06
R_Conv_1_1_8_0_0_2_1 L0_N149 L1_N42 1.1947062568e+05
R_Conv_1_1_8_0_1_0_0 L0_N200 L1_N42 3.4555602430e+05
R_Conv_1_1_8_0_1_0_1 L0_N201 L1_N42 1.2140655673e+05
R_Conv_1_1_8_0_1_1_0 L0_N202 L1_N42 2.0024008865e+05
R_Conv_1_1_8_0_1_1_1 L0_N203 L1_N42 1.3019124074e+05
R_Conv_1_1_8_0_1_2_0 L0_N204 L1_N42 1.1085089352e+05
R_Conv_1_1_8_0_1_2_1 L0_N205 L1_N42 2.5251460583e+05
R_Conv_1_1_8_0_2_0_0 L0_N256 L1_N42 1.1040315248e+05
R_Conv_1_1_8_0_2_0_1 L0_N257 L1_N42 1.2105931856e+05
R_Conv_1_1_8_0_2_1_0 L0_N258 L1_N42 1.0186236681e+05
R_Conv_1_1_8_0_2_1_1 L0_N259 L1_N42 3.8798345399e+05
R_Conv_1_1_8_0_2_2_0 L0_N260 L1_N42 4.4022254443e+06
R_Conv_1_1_8_0_2_2_1 L0_N261 L1_N42 1.5358515901e+05
*
R_Conv_1_1_8_1_0_0_0 L0_N144 L1_N43 1.2123709737e+05
R_Conv_1_1_8_1_0_0_1 L0_N145 L1_N43 1.0849154640e+05
R_Conv_1_1_8_1_0_1_0 L0_N146 L1_N43 2.0480317885e+05
R_Conv_1_1_8_1_0_1_1 L0_N147 L1_N43 1.6641635952e+05
R_Conv_1_1_8_1_0_2_0 L0_N148 L1_N43 1.1683261279e+06
R_Conv_1_1_8_1_0_2_1 L0_N149 L1_N43 1.1602008983e+05
R_Conv_1_1_8_1_1_0_0 L0_N200 L1_N43 1.2296662853e+05
R_Conv_1_1_8_1_1_0_1 L0_N201 L1_N43 1.6882235068e+05
R_Conv_1_1_8_1_1_1_0 L0_N202 L1_N43 1.0472083211e+05
R_Conv_1_1_8_1_1_1_1 L0_N203 L1_N43 2.1167619859e+05
R_Conv_1_1_8_1_1_2_0 L0_N204 L1_N43 1.3518319025e+05
R_Conv_1_1_8_1_1_2_1 L0_N205 L1_N43 1.4280846670e+05
R_Conv_1_1_8_1_2_0_0 L0_N256 L1_N43 1.1620759255e+05
R_Conv_1_1_8_1_2_0_1 L0_N257 L1_N43 1.6895116802e+05
R_Conv_1_1_8_1_2_1_0 L0_N258 L1_N43 1.2455043512e+06
R_Conv_1_1_8_1_2_1_1 L0_N259 L1_N43 1.1694022847e+05
R_Conv_1_1_8_1_2_2_0 L0_N260 L1_N43 1.5663616684e+06
R_Conv_1_1_8_1_2_2_1 L0_N261 L1_N43 2.1466641264e+05
*
R_Conv_1_1_9_0_0_0_0 L0_N148 L1_N44 3.0927915375e+05
R_Conv_1_1_9_0_0_0_1 L0_N149 L1_N44 3.6154472179e+05
R_Conv_1_1_9_0_0_1_0 L0_N150 L1_N44 1.2307612303e+05
R_Conv_1_1_9_0_0_1_1 L0_N151 L1_N44 1.3361401953e+06
R_Conv_1_1_9_0_0_2_0 L0_N152 L1_N44 1.1771240850e+06
R_Conv_1_1_9_0_0_2_1 L0_N153 L1_N44 1.1947062568e+05
R_Conv_1_1_9_0_1_0_0 L0_N204 L1_N44 3.4555602430e+05
R_Conv_1_1_9_0_1_0_1 L0_N205 L1_N44 1.2140655673e+05
R_Conv_1_1_9_0_1_1_0 L0_N206 L1_N44 2.0024008865e+05
R_Conv_1_1_9_0_1_1_1 L0_N207 L1_N44 1.3019124074e+05
R_Conv_1_1_9_0_1_2_0 L0_N208 L1_N44 1.1085089352e+05
R_Conv_1_1_9_0_1_2_1 L0_N209 L1_N44 2.5251460583e+05
R_Conv_1_1_9_0_2_0_0 L0_N260 L1_N44 1.1040315248e+05
R_Conv_1_1_9_0_2_0_1 L0_N261 L1_N44 1.2105931856e+05
R_Conv_1_1_9_0_2_1_0 L0_N262 L1_N44 1.0186236681e+05
R_Conv_1_1_9_0_2_1_1 L0_N263 L1_N44 3.8798345399e+05
R_Conv_1_1_9_0_2_2_0 L0_N264 L1_N44 4.4022254443e+06
R_Conv_1_1_9_0_2_2_1 L0_N265 L1_N44 1.5358515901e+05
*
R_Conv_1_1_9_1_0_0_0 L0_N148 L1_N45 1.2123709737e+05
R_Conv_1_1_9_1_0_0_1 L0_N149 L1_N45 1.0849154640e+05
R_Conv_1_1_9_1_0_1_0 L0_N150 L1_N45 2.0480317885e+05
R_Conv_1_1_9_1_0_1_1 L0_N151 L1_N45 1.6641635952e+05
R_Conv_1_1_9_1_0_2_0 L0_N152 L1_N45 1.1683261279e+06
R_Conv_1_1_9_1_0_2_1 L0_N153 L1_N45 1.1602008983e+05
R_Conv_1_1_9_1_1_0_0 L0_N204 L1_N45 1.2296662853e+05
R_Conv_1_1_9_1_1_0_1 L0_N205 L1_N45 1.6882235068e+05
R_Conv_1_1_9_1_1_1_0 L0_N206 L1_N45 1.0472083211e+05
R_Conv_1_1_9_1_1_1_1 L0_N207 L1_N45 2.1167619859e+05
R_Conv_1_1_9_1_1_2_0 L0_N208 L1_N45 1.3518319025e+05
R_Conv_1_1_9_1_1_2_1 L0_N209 L1_N45 1.4280846670e+05
R_Conv_1_1_9_1_2_0_0 L0_N260 L1_N45 1.1620759255e+05
R_Conv_1_1_9_1_2_0_1 L0_N261 L1_N45 1.6895116802e+05
R_Conv_1_1_9_1_2_1_0 L0_N262 L1_N45 1.2455043512e+06
R_Conv_1_1_9_1_2_1_1 L0_N263 L1_N45 1.1694022847e+05
R_Conv_1_1_9_1_2_2_0 L0_N264 L1_N45 1.5663616684e+06
R_Conv_1_1_9_1_2_2_1 L0_N265 L1_N45 2.1466641264e+05
*
R_Conv_1_1_10_0_0_0_0 L0_N152 L1_N46 3.0927915375e+05
R_Conv_1_1_10_0_0_0_1 L0_N153 L1_N46 3.6154472179e+05
R_Conv_1_1_10_0_0_1_0 L0_N154 L1_N46 1.2307612303e+05
R_Conv_1_1_10_0_0_1_1 L0_N155 L1_N46 1.3361401953e+06
R_Conv_1_1_10_0_0_2_0 L0_N156 L1_N46 1.1771240850e+06
R_Conv_1_1_10_0_0_2_1 L0_N157 L1_N46 1.1947062568e+05
R_Conv_1_1_10_0_1_0_0 L0_N208 L1_N46 3.4555602430e+05
R_Conv_1_1_10_0_1_0_1 L0_N209 L1_N46 1.2140655673e+05
R_Conv_1_1_10_0_1_1_0 L0_N210 L1_N46 2.0024008865e+05
R_Conv_1_1_10_0_1_1_1 L0_N211 L1_N46 1.3019124074e+05
R_Conv_1_1_10_0_1_2_0 L0_N212 L1_N46 1.1085089352e+05
R_Conv_1_1_10_0_1_2_1 L0_N213 L1_N46 2.5251460583e+05
R_Conv_1_1_10_0_2_0_0 L0_N264 L1_N46 1.1040315248e+05
R_Conv_1_1_10_0_2_0_1 L0_N265 L1_N46 1.2105931856e+05
R_Conv_1_1_10_0_2_1_0 L0_N266 L1_N46 1.0186236681e+05
R_Conv_1_1_10_0_2_1_1 L0_N267 L1_N46 3.8798345399e+05
R_Conv_1_1_10_0_2_2_0 L0_N268 L1_N46 4.4022254443e+06
R_Conv_1_1_10_0_2_2_1 L0_N269 L1_N46 1.5358515901e+05
*
R_Conv_1_1_10_1_0_0_0 L0_N152 L1_N47 1.2123709737e+05
R_Conv_1_1_10_1_0_0_1 L0_N153 L1_N47 1.0849154640e+05
R_Conv_1_1_10_1_0_1_0 L0_N154 L1_N47 2.0480317885e+05
R_Conv_1_1_10_1_0_1_1 L0_N155 L1_N47 1.6641635952e+05
R_Conv_1_1_10_1_0_2_0 L0_N156 L1_N47 1.1683261279e+06
R_Conv_1_1_10_1_0_2_1 L0_N157 L1_N47 1.1602008983e+05
R_Conv_1_1_10_1_1_0_0 L0_N208 L1_N47 1.2296662853e+05
R_Conv_1_1_10_1_1_0_1 L0_N209 L1_N47 1.6882235068e+05
R_Conv_1_1_10_1_1_1_0 L0_N210 L1_N47 1.0472083211e+05
R_Conv_1_1_10_1_1_1_1 L0_N211 L1_N47 2.1167619859e+05
R_Conv_1_1_10_1_1_2_0 L0_N212 L1_N47 1.3518319025e+05
R_Conv_1_1_10_1_1_2_1 L0_N213 L1_N47 1.4280846670e+05
R_Conv_1_1_10_1_2_0_0 L0_N264 L1_N47 1.1620759255e+05
R_Conv_1_1_10_1_2_0_1 L0_N265 L1_N47 1.6895116802e+05
R_Conv_1_1_10_1_2_1_0 L0_N266 L1_N47 1.2455043512e+06
R_Conv_1_1_10_1_2_1_1 L0_N267 L1_N47 1.1694022847e+05
R_Conv_1_1_10_1_2_2_0 L0_N268 L1_N47 1.5663616684e+06
R_Conv_1_1_10_1_2_2_1 L0_N269 L1_N47 2.1466641264e+05
*
R_Conv_1_1_11_0_0_0_0 L0_N156 L1_N48 3.0927915375e+05
R_Conv_1_1_11_0_0_0_1 L0_N157 L1_N48 3.6154472179e+05
R_Conv_1_1_11_0_0_1_0 L0_N158 L1_N48 1.2307612303e+05
R_Conv_1_1_11_0_0_1_1 L0_N159 L1_N48 1.3361401953e+06
R_Conv_1_1_11_0_0_2_0 L0_N160 L1_N48 1.1771240850e+06
R_Conv_1_1_11_0_0_2_1 L0_N161 L1_N48 1.1947062568e+05
R_Conv_1_1_11_0_1_0_0 L0_N212 L1_N48 3.4555602430e+05
R_Conv_1_1_11_0_1_0_1 L0_N213 L1_N48 1.2140655673e+05
R_Conv_1_1_11_0_1_1_0 L0_N214 L1_N48 2.0024008865e+05
R_Conv_1_1_11_0_1_1_1 L0_N215 L1_N48 1.3019124074e+05
R_Conv_1_1_11_0_1_2_0 L0_N216 L1_N48 1.1085089352e+05
R_Conv_1_1_11_0_1_2_1 L0_N217 L1_N48 2.5251460583e+05
R_Conv_1_1_11_0_2_0_0 L0_N268 L1_N48 1.1040315248e+05
R_Conv_1_1_11_0_2_0_1 L0_N269 L1_N48 1.2105931856e+05
R_Conv_1_1_11_0_2_1_0 L0_N270 L1_N48 1.0186236681e+05
R_Conv_1_1_11_0_2_1_1 L0_N271 L1_N48 3.8798345399e+05
R_Conv_1_1_11_0_2_2_0 L0_N272 L1_N48 4.4022254443e+06
R_Conv_1_1_11_0_2_2_1 L0_N273 L1_N48 1.5358515901e+05
*
R_Conv_1_1_11_1_0_0_0 L0_N156 L1_N49 1.2123709737e+05
R_Conv_1_1_11_1_0_0_1 L0_N157 L1_N49 1.0849154640e+05
R_Conv_1_1_11_1_0_1_0 L0_N158 L1_N49 2.0480317885e+05
R_Conv_1_1_11_1_0_1_1 L0_N159 L1_N49 1.6641635952e+05
R_Conv_1_1_11_1_0_2_0 L0_N160 L1_N49 1.1683261279e+06
R_Conv_1_1_11_1_0_2_1 L0_N161 L1_N49 1.1602008983e+05
R_Conv_1_1_11_1_1_0_0 L0_N212 L1_N49 1.2296662853e+05
R_Conv_1_1_11_1_1_0_1 L0_N213 L1_N49 1.6882235068e+05
R_Conv_1_1_11_1_1_1_0 L0_N214 L1_N49 1.0472083211e+05
R_Conv_1_1_11_1_1_1_1 L0_N215 L1_N49 2.1167619859e+05
R_Conv_1_1_11_1_1_2_0 L0_N216 L1_N49 1.3518319025e+05
R_Conv_1_1_11_1_1_2_1 L0_N217 L1_N49 1.4280846670e+05
R_Conv_1_1_11_1_2_0_0 L0_N268 L1_N49 1.1620759255e+05
R_Conv_1_1_11_1_2_0_1 L0_N269 L1_N49 1.6895116802e+05
R_Conv_1_1_11_1_2_1_0 L0_N270 L1_N49 1.2455043512e+06
R_Conv_1_1_11_1_2_1_1 L0_N271 L1_N49 1.1694022847e+05
R_Conv_1_1_11_1_2_2_0 L0_N272 L1_N49 1.5663616684e+06
R_Conv_1_1_11_1_2_2_1 L0_N273 L1_N49 2.1466641264e+05
*
R_Conv_1_1_12_0_0_0_0 L0_N160 L1_N50 3.0927915375e+05
R_Conv_1_1_12_0_0_0_1 L0_N161 L1_N50 3.6154472179e+05
R_Conv_1_1_12_0_0_1_0 L0_N162 L1_N50 1.2307612303e+05
R_Conv_1_1_12_0_0_1_1 L0_N163 L1_N50 1.3361401953e+06
R_Conv_1_1_12_0_0_2_0 L0_N164 L1_N50 1.1771240850e+06
R_Conv_1_1_12_0_0_2_1 L0_N165 L1_N50 1.1947062568e+05
R_Conv_1_1_12_0_1_0_0 L0_N216 L1_N50 3.4555602430e+05
R_Conv_1_1_12_0_1_0_1 L0_N217 L1_N50 1.2140655673e+05
R_Conv_1_1_12_0_1_1_0 L0_N218 L1_N50 2.0024008865e+05
R_Conv_1_1_12_0_1_1_1 L0_N219 L1_N50 1.3019124074e+05
R_Conv_1_1_12_0_1_2_0 L0_N220 L1_N50 1.1085089352e+05
R_Conv_1_1_12_0_1_2_1 L0_N221 L1_N50 2.5251460583e+05
R_Conv_1_1_12_0_2_0_0 L0_N272 L1_N50 1.1040315248e+05
R_Conv_1_1_12_0_2_0_1 L0_N273 L1_N50 1.2105931856e+05
R_Conv_1_1_12_0_2_1_0 L0_N274 L1_N50 1.0186236681e+05
R_Conv_1_1_12_0_2_1_1 L0_N275 L1_N50 3.8798345399e+05
R_Conv_1_1_12_0_2_2_0 L0_N276 L1_N50 4.4022254443e+06
R_Conv_1_1_12_0_2_2_1 L0_N277 L1_N50 1.5358515901e+05
*
R_Conv_1_1_12_1_0_0_0 L0_N160 L1_N51 1.2123709737e+05
R_Conv_1_1_12_1_0_0_1 L0_N161 L1_N51 1.0849154640e+05
R_Conv_1_1_12_1_0_1_0 L0_N162 L1_N51 2.0480317885e+05
R_Conv_1_1_12_1_0_1_1 L0_N163 L1_N51 1.6641635952e+05
R_Conv_1_1_12_1_0_2_0 L0_N164 L1_N51 1.1683261279e+06
R_Conv_1_1_12_1_0_2_1 L0_N165 L1_N51 1.1602008983e+05
R_Conv_1_1_12_1_1_0_0 L0_N216 L1_N51 1.2296662853e+05
R_Conv_1_1_12_1_1_0_1 L0_N217 L1_N51 1.6882235068e+05
R_Conv_1_1_12_1_1_1_0 L0_N218 L1_N51 1.0472083211e+05
R_Conv_1_1_12_1_1_1_1 L0_N219 L1_N51 2.1167619859e+05
R_Conv_1_1_12_1_1_2_0 L0_N220 L1_N51 1.3518319025e+05
R_Conv_1_1_12_1_1_2_1 L0_N221 L1_N51 1.4280846670e+05
R_Conv_1_1_12_1_2_0_0 L0_N272 L1_N51 1.1620759255e+05
R_Conv_1_1_12_1_2_0_1 L0_N273 L1_N51 1.6895116802e+05
R_Conv_1_1_12_1_2_1_0 L0_N274 L1_N51 1.2455043512e+06
R_Conv_1_1_12_1_2_1_1 L0_N275 L1_N51 1.1694022847e+05
R_Conv_1_1_12_1_2_2_0 L0_N276 L1_N51 1.5663616684e+06
R_Conv_1_1_12_1_2_2_1 L0_N277 L1_N51 2.1466641264e+05
*
R_Conv_1_2_0_0_0_0_0 L0_N224 L1_N52 3.0927915375e+05
R_Conv_1_2_0_0_0_0_1 L0_N225 L1_N52 3.6154472179e+05
R_Conv_1_2_0_0_0_1_0 L0_N226 L1_N52 1.2307612303e+05
R_Conv_1_2_0_0_0_1_1 L0_N227 L1_N52 1.3361401953e+06
R_Conv_1_2_0_0_0_2_0 L0_N228 L1_N52 1.1771240850e+06
R_Conv_1_2_0_0_0_2_1 L0_N229 L1_N52 1.1947062568e+05
R_Conv_1_2_0_0_1_0_0 L0_N280 L1_N52 3.4555602430e+05
R_Conv_1_2_0_0_1_0_1 L0_N281 L1_N52 1.2140655673e+05
R_Conv_1_2_0_0_1_1_0 L0_N282 L1_N52 2.0024008865e+05
R_Conv_1_2_0_0_1_1_1 L0_N283 L1_N52 1.3019124074e+05
R_Conv_1_2_0_0_1_2_0 L0_N284 L1_N52 1.1085089352e+05
R_Conv_1_2_0_0_1_2_1 L0_N285 L1_N52 2.5251460583e+05
R_Conv_1_2_0_0_2_0_0 L0_N336 L1_N52 1.1040315248e+05
R_Conv_1_2_0_0_2_0_1 L0_N337 L1_N52 1.2105931856e+05
R_Conv_1_2_0_0_2_1_0 L0_N338 L1_N52 1.0186236681e+05
R_Conv_1_2_0_0_2_1_1 L0_N339 L1_N52 3.8798345399e+05
R_Conv_1_2_0_0_2_2_0 L0_N340 L1_N52 4.4022254443e+06
R_Conv_1_2_0_0_2_2_1 L0_N341 L1_N52 1.5358515901e+05
*
R_Conv_1_2_0_1_0_0_0 L0_N224 L1_N53 1.2123709737e+05
R_Conv_1_2_0_1_0_0_1 L0_N225 L1_N53 1.0849154640e+05
R_Conv_1_2_0_1_0_1_0 L0_N226 L1_N53 2.0480317885e+05
R_Conv_1_2_0_1_0_1_1 L0_N227 L1_N53 1.6641635952e+05
R_Conv_1_2_0_1_0_2_0 L0_N228 L1_N53 1.1683261279e+06
R_Conv_1_2_0_1_0_2_1 L0_N229 L1_N53 1.1602008983e+05
R_Conv_1_2_0_1_1_0_0 L0_N280 L1_N53 1.2296662853e+05
R_Conv_1_2_0_1_1_0_1 L0_N281 L1_N53 1.6882235068e+05
R_Conv_1_2_0_1_1_1_0 L0_N282 L1_N53 1.0472083211e+05
R_Conv_1_2_0_1_1_1_1 L0_N283 L1_N53 2.1167619859e+05
R_Conv_1_2_0_1_1_2_0 L0_N284 L1_N53 1.3518319025e+05
R_Conv_1_2_0_1_1_2_1 L0_N285 L1_N53 1.4280846670e+05
R_Conv_1_2_0_1_2_0_0 L0_N336 L1_N53 1.1620759255e+05
R_Conv_1_2_0_1_2_0_1 L0_N337 L1_N53 1.6895116802e+05
R_Conv_1_2_0_1_2_1_0 L0_N338 L1_N53 1.2455043512e+06
R_Conv_1_2_0_1_2_1_1 L0_N339 L1_N53 1.1694022847e+05
R_Conv_1_2_0_1_2_2_0 L0_N340 L1_N53 1.5663616684e+06
R_Conv_1_2_0_1_2_2_1 L0_N341 L1_N53 2.1466641264e+05
*
R_Conv_1_2_1_0_0_0_0 L0_N228 L1_N54 3.0927915375e+05
R_Conv_1_2_1_0_0_0_1 L0_N229 L1_N54 3.6154472179e+05
R_Conv_1_2_1_0_0_1_0 L0_N230 L1_N54 1.2307612303e+05
R_Conv_1_2_1_0_0_1_1 L0_N231 L1_N54 1.3361401953e+06
R_Conv_1_2_1_0_0_2_0 L0_N232 L1_N54 1.1771240850e+06
R_Conv_1_2_1_0_0_2_1 L0_N233 L1_N54 1.1947062568e+05
R_Conv_1_2_1_0_1_0_0 L0_N284 L1_N54 3.4555602430e+05
R_Conv_1_2_1_0_1_0_1 L0_N285 L1_N54 1.2140655673e+05
R_Conv_1_2_1_0_1_1_0 L0_N286 L1_N54 2.0024008865e+05
R_Conv_1_2_1_0_1_1_1 L0_N287 L1_N54 1.3019124074e+05
R_Conv_1_2_1_0_1_2_0 L0_N288 L1_N54 1.1085089352e+05
R_Conv_1_2_1_0_1_2_1 L0_N289 L1_N54 2.5251460583e+05
R_Conv_1_2_1_0_2_0_0 L0_N340 L1_N54 1.1040315248e+05
R_Conv_1_2_1_0_2_0_1 L0_N341 L1_N54 1.2105931856e+05
R_Conv_1_2_1_0_2_1_0 L0_N342 L1_N54 1.0186236681e+05
R_Conv_1_2_1_0_2_1_1 L0_N343 L1_N54 3.8798345399e+05
R_Conv_1_2_1_0_2_2_0 L0_N344 L1_N54 4.4022254443e+06
R_Conv_1_2_1_0_2_2_1 L0_N345 L1_N54 1.5358515901e+05
*
R_Conv_1_2_1_1_0_0_0 L0_N228 L1_N55 1.2123709737e+05
R_Conv_1_2_1_1_0_0_1 L0_N229 L1_N55 1.0849154640e+05
R_Conv_1_2_1_1_0_1_0 L0_N230 L1_N55 2.0480317885e+05
R_Conv_1_2_1_1_0_1_1 L0_N231 L1_N55 1.6641635952e+05
R_Conv_1_2_1_1_0_2_0 L0_N232 L1_N55 1.1683261279e+06
R_Conv_1_2_1_1_0_2_1 L0_N233 L1_N55 1.1602008983e+05
R_Conv_1_2_1_1_1_0_0 L0_N284 L1_N55 1.2296662853e+05
R_Conv_1_2_1_1_1_0_1 L0_N285 L1_N55 1.6882235068e+05
R_Conv_1_2_1_1_1_1_0 L0_N286 L1_N55 1.0472083211e+05
R_Conv_1_2_1_1_1_1_1 L0_N287 L1_N55 2.1167619859e+05
R_Conv_1_2_1_1_1_2_0 L0_N288 L1_N55 1.3518319025e+05
R_Conv_1_2_1_1_1_2_1 L0_N289 L1_N55 1.4280846670e+05
R_Conv_1_2_1_1_2_0_0 L0_N340 L1_N55 1.1620759255e+05
R_Conv_1_2_1_1_2_0_1 L0_N341 L1_N55 1.6895116802e+05
R_Conv_1_2_1_1_2_1_0 L0_N342 L1_N55 1.2455043512e+06
R_Conv_1_2_1_1_2_1_1 L0_N343 L1_N55 1.1694022847e+05
R_Conv_1_2_1_1_2_2_0 L0_N344 L1_N55 1.5663616684e+06
R_Conv_1_2_1_1_2_2_1 L0_N345 L1_N55 2.1466641264e+05
*
R_Conv_1_2_2_0_0_0_0 L0_N232 L1_N56 3.0927915375e+05
R_Conv_1_2_2_0_0_0_1 L0_N233 L1_N56 3.6154472179e+05
R_Conv_1_2_2_0_0_1_0 L0_N234 L1_N56 1.2307612303e+05
R_Conv_1_2_2_0_0_1_1 L0_N235 L1_N56 1.3361401953e+06
R_Conv_1_2_2_0_0_2_0 L0_N236 L1_N56 1.1771240850e+06
R_Conv_1_2_2_0_0_2_1 L0_N237 L1_N56 1.1947062568e+05
R_Conv_1_2_2_0_1_0_0 L0_N288 L1_N56 3.4555602430e+05
R_Conv_1_2_2_0_1_0_1 L0_N289 L1_N56 1.2140655673e+05
R_Conv_1_2_2_0_1_1_0 L0_N290 L1_N56 2.0024008865e+05
R_Conv_1_2_2_0_1_1_1 L0_N291 L1_N56 1.3019124074e+05
R_Conv_1_2_2_0_1_2_0 L0_N292 L1_N56 1.1085089352e+05
R_Conv_1_2_2_0_1_2_1 L0_N293 L1_N56 2.5251460583e+05
R_Conv_1_2_2_0_2_0_0 L0_N344 L1_N56 1.1040315248e+05
R_Conv_1_2_2_0_2_0_1 L0_N345 L1_N56 1.2105931856e+05
R_Conv_1_2_2_0_2_1_0 L0_N346 L1_N56 1.0186236681e+05
R_Conv_1_2_2_0_2_1_1 L0_N347 L1_N56 3.8798345399e+05
R_Conv_1_2_2_0_2_2_0 L0_N348 L1_N56 4.4022254443e+06
R_Conv_1_2_2_0_2_2_1 L0_N349 L1_N56 1.5358515901e+05
*
R_Conv_1_2_2_1_0_0_0 L0_N232 L1_N57 1.2123709737e+05
R_Conv_1_2_2_1_0_0_1 L0_N233 L1_N57 1.0849154640e+05
R_Conv_1_2_2_1_0_1_0 L0_N234 L1_N57 2.0480317885e+05
R_Conv_1_2_2_1_0_1_1 L0_N235 L1_N57 1.6641635952e+05
R_Conv_1_2_2_1_0_2_0 L0_N236 L1_N57 1.1683261279e+06
R_Conv_1_2_2_1_0_2_1 L0_N237 L1_N57 1.1602008983e+05
R_Conv_1_2_2_1_1_0_0 L0_N288 L1_N57 1.2296662853e+05
R_Conv_1_2_2_1_1_0_1 L0_N289 L1_N57 1.6882235068e+05
R_Conv_1_2_2_1_1_1_0 L0_N290 L1_N57 1.0472083211e+05
R_Conv_1_2_2_1_1_1_1 L0_N291 L1_N57 2.1167619859e+05
R_Conv_1_2_2_1_1_2_0 L0_N292 L1_N57 1.3518319025e+05
R_Conv_1_2_2_1_1_2_1 L0_N293 L1_N57 1.4280846670e+05
R_Conv_1_2_2_1_2_0_0 L0_N344 L1_N57 1.1620759255e+05
R_Conv_1_2_2_1_2_0_1 L0_N345 L1_N57 1.6895116802e+05
R_Conv_1_2_2_1_2_1_0 L0_N346 L1_N57 1.2455043512e+06
R_Conv_1_2_2_1_2_1_1 L0_N347 L1_N57 1.1694022847e+05
R_Conv_1_2_2_1_2_2_0 L0_N348 L1_N57 1.5663616684e+06
R_Conv_1_2_2_1_2_2_1 L0_N349 L1_N57 2.1466641264e+05
*
R_Conv_1_2_3_0_0_0_0 L0_N236 L1_N58 3.0927915375e+05
R_Conv_1_2_3_0_0_0_1 L0_N237 L1_N58 3.6154472179e+05
R_Conv_1_2_3_0_0_1_0 L0_N238 L1_N58 1.2307612303e+05
R_Conv_1_2_3_0_0_1_1 L0_N239 L1_N58 1.3361401953e+06
R_Conv_1_2_3_0_0_2_0 L0_N240 L1_N58 1.1771240850e+06
R_Conv_1_2_3_0_0_2_1 L0_N241 L1_N58 1.1947062568e+05
R_Conv_1_2_3_0_1_0_0 L0_N292 L1_N58 3.4555602430e+05
R_Conv_1_2_3_0_1_0_1 L0_N293 L1_N58 1.2140655673e+05
R_Conv_1_2_3_0_1_1_0 L0_N294 L1_N58 2.0024008865e+05
R_Conv_1_2_3_0_1_1_1 L0_N295 L1_N58 1.3019124074e+05
R_Conv_1_2_3_0_1_2_0 L0_N296 L1_N58 1.1085089352e+05
R_Conv_1_2_3_0_1_2_1 L0_N297 L1_N58 2.5251460583e+05
R_Conv_1_2_3_0_2_0_0 L0_N348 L1_N58 1.1040315248e+05
R_Conv_1_2_3_0_2_0_1 L0_N349 L1_N58 1.2105931856e+05
R_Conv_1_2_3_0_2_1_0 L0_N350 L1_N58 1.0186236681e+05
R_Conv_1_2_3_0_2_1_1 L0_N351 L1_N58 3.8798345399e+05
R_Conv_1_2_3_0_2_2_0 L0_N352 L1_N58 4.4022254443e+06
R_Conv_1_2_3_0_2_2_1 L0_N353 L1_N58 1.5358515901e+05
*
R_Conv_1_2_3_1_0_0_0 L0_N236 L1_N59 1.2123709737e+05
R_Conv_1_2_3_1_0_0_1 L0_N237 L1_N59 1.0849154640e+05
R_Conv_1_2_3_1_0_1_0 L0_N238 L1_N59 2.0480317885e+05
R_Conv_1_2_3_1_0_1_1 L0_N239 L1_N59 1.6641635952e+05
R_Conv_1_2_3_1_0_2_0 L0_N240 L1_N59 1.1683261279e+06
R_Conv_1_2_3_1_0_2_1 L0_N241 L1_N59 1.1602008983e+05
R_Conv_1_2_3_1_1_0_0 L0_N292 L1_N59 1.2296662853e+05
R_Conv_1_2_3_1_1_0_1 L0_N293 L1_N59 1.6882235068e+05
R_Conv_1_2_3_1_1_1_0 L0_N294 L1_N59 1.0472083211e+05
R_Conv_1_2_3_1_1_1_1 L0_N295 L1_N59 2.1167619859e+05
R_Conv_1_2_3_1_1_2_0 L0_N296 L1_N59 1.3518319025e+05
R_Conv_1_2_3_1_1_2_1 L0_N297 L1_N59 1.4280846670e+05
R_Conv_1_2_3_1_2_0_0 L0_N348 L1_N59 1.1620759255e+05
R_Conv_1_2_3_1_2_0_1 L0_N349 L1_N59 1.6895116802e+05
R_Conv_1_2_3_1_2_1_0 L0_N350 L1_N59 1.2455043512e+06
R_Conv_1_2_3_1_2_1_1 L0_N351 L1_N59 1.1694022847e+05
R_Conv_1_2_3_1_2_2_0 L0_N352 L1_N59 1.5663616684e+06
R_Conv_1_2_3_1_2_2_1 L0_N353 L1_N59 2.1466641264e+05
*
R_Conv_1_2_4_0_0_0_0 L0_N240 L1_N60 3.0927915375e+05
R_Conv_1_2_4_0_0_0_1 L0_N241 L1_N60 3.6154472179e+05
R_Conv_1_2_4_0_0_1_0 L0_N242 L1_N60 1.2307612303e+05
R_Conv_1_2_4_0_0_1_1 L0_N243 L1_N60 1.3361401953e+06
R_Conv_1_2_4_0_0_2_0 L0_N244 L1_N60 1.1771240850e+06
R_Conv_1_2_4_0_0_2_1 L0_N245 L1_N60 1.1947062568e+05
R_Conv_1_2_4_0_1_0_0 L0_N296 L1_N60 3.4555602430e+05
R_Conv_1_2_4_0_1_0_1 L0_N297 L1_N60 1.2140655673e+05
R_Conv_1_2_4_0_1_1_0 L0_N298 L1_N60 2.0024008865e+05
R_Conv_1_2_4_0_1_1_1 L0_N299 L1_N60 1.3019124074e+05
R_Conv_1_2_4_0_1_2_0 L0_N300 L1_N60 1.1085089352e+05
R_Conv_1_2_4_0_1_2_1 L0_N301 L1_N60 2.5251460583e+05
R_Conv_1_2_4_0_2_0_0 L0_N352 L1_N60 1.1040315248e+05
R_Conv_1_2_4_0_2_0_1 L0_N353 L1_N60 1.2105931856e+05
R_Conv_1_2_4_0_2_1_0 L0_N354 L1_N60 1.0186236681e+05
R_Conv_1_2_4_0_2_1_1 L0_N355 L1_N60 3.8798345399e+05
R_Conv_1_2_4_0_2_2_0 L0_N356 L1_N60 4.4022254443e+06
R_Conv_1_2_4_0_2_2_1 L0_N357 L1_N60 1.5358515901e+05
*
R_Conv_1_2_4_1_0_0_0 L0_N240 L1_N61 1.2123709737e+05
R_Conv_1_2_4_1_0_0_1 L0_N241 L1_N61 1.0849154640e+05
R_Conv_1_2_4_1_0_1_0 L0_N242 L1_N61 2.0480317885e+05
R_Conv_1_2_4_1_0_1_1 L0_N243 L1_N61 1.6641635952e+05
R_Conv_1_2_4_1_0_2_0 L0_N244 L1_N61 1.1683261279e+06
R_Conv_1_2_4_1_0_2_1 L0_N245 L1_N61 1.1602008983e+05
R_Conv_1_2_4_1_1_0_0 L0_N296 L1_N61 1.2296662853e+05
R_Conv_1_2_4_1_1_0_1 L0_N297 L1_N61 1.6882235068e+05
R_Conv_1_2_4_1_1_1_0 L0_N298 L1_N61 1.0472083211e+05
R_Conv_1_2_4_1_1_1_1 L0_N299 L1_N61 2.1167619859e+05
R_Conv_1_2_4_1_1_2_0 L0_N300 L1_N61 1.3518319025e+05
R_Conv_1_2_4_1_1_2_1 L0_N301 L1_N61 1.4280846670e+05
R_Conv_1_2_4_1_2_0_0 L0_N352 L1_N61 1.1620759255e+05
R_Conv_1_2_4_1_2_0_1 L0_N353 L1_N61 1.6895116802e+05
R_Conv_1_2_4_1_2_1_0 L0_N354 L1_N61 1.2455043512e+06
R_Conv_1_2_4_1_2_1_1 L0_N355 L1_N61 1.1694022847e+05
R_Conv_1_2_4_1_2_2_0 L0_N356 L1_N61 1.5663616684e+06
R_Conv_1_2_4_1_2_2_1 L0_N357 L1_N61 2.1466641264e+05
*
R_Conv_1_2_5_0_0_0_0 L0_N244 L1_N62 3.0927915375e+05
R_Conv_1_2_5_0_0_0_1 L0_N245 L1_N62 3.6154472179e+05
R_Conv_1_2_5_0_0_1_0 L0_N246 L1_N62 1.2307612303e+05
R_Conv_1_2_5_0_0_1_1 L0_N247 L1_N62 1.3361401953e+06
R_Conv_1_2_5_0_0_2_0 L0_N248 L1_N62 1.1771240850e+06
R_Conv_1_2_5_0_0_2_1 L0_N249 L1_N62 1.1947062568e+05
R_Conv_1_2_5_0_1_0_0 L0_N300 L1_N62 3.4555602430e+05
R_Conv_1_2_5_0_1_0_1 L0_N301 L1_N62 1.2140655673e+05
R_Conv_1_2_5_0_1_1_0 L0_N302 L1_N62 2.0024008865e+05
R_Conv_1_2_5_0_1_1_1 L0_N303 L1_N62 1.3019124074e+05
R_Conv_1_2_5_0_1_2_0 L0_N304 L1_N62 1.1085089352e+05
R_Conv_1_2_5_0_1_2_1 L0_N305 L1_N62 2.5251460583e+05
R_Conv_1_2_5_0_2_0_0 L0_N356 L1_N62 1.1040315248e+05
R_Conv_1_2_5_0_2_0_1 L0_N357 L1_N62 1.2105931856e+05
R_Conv_1_2_5_0_2_1_0 L0_N358 L1_N62 1.0186236681e+05
R_Conv_1_2_5_0_2_1_1 L0_N359 L1_N62 3.8798345399e+05
R_Conv_1_2_5_0_2_2_0 L0_N360 L1_N62 4.4022254443e+06
R_Conv_1_2_5_0_2_2_1 L0_N361 L1_N62 1.5358515901e+05
*
R_Conv_1_2_5_1_0_0_0 L0_N244 L1_N63 1.2123709737e+05
R_Conv_1_2_5_1_0_0_1 L0_N245 L1_N63 1.0849154640e+05
R_Conv_1_2_5_1_0_1_0 L0_N246 L1_N63 2.0480317885e+05
R_Conv_1_2_5_1_0_1_1 L0_N247 L1_N63 1.6641635952e+05
R_Conv_1_2_5_1_0_2_0 L0_N248 L1_N63 1.1683261279e+06
R_Conv_1_2_5_1_0_2_1 L0_N249 L1_N63 1.1602008983e+05
R_Conv_1_2_5_1_1_0_0 L0_N300 L1_N63 1.2296662853e+05
R_Conv_1_2_5_1_1_0_1 L0_N301 L1_N63 1.6882235068e+05
R_Conv_1_2_5_1_1_1_0 L0_N302 L1_N63 1.0472083211e+05
R_Conv_1_2_5_1_1_1_1 L0_N303 L1_N63 2.1167619859e+05
R_Conv_1_2_5_1_1_2_0 L0_N304 L1_N63 1.3518319025e+05
R_Conv_1_2_5_1_1_2_1 L0_N305 L1_N63 1.4280846670e+05
R_Conv_1_2_5_1_2_0_0 L0_N356 L1_N63 1.1620759255e+05
R_Conv_1_2_5_1_2_0_1 L0_N357 L1_N63 1.6895116802e+05
R_Conv_1_2_5_1_2_1_0 L0_N358 L1_N63 1.2455043512e+06
R_Conv_1_2_5_1_2_1_1 L0_N359 L1_N63 1.1694022847e+05
R_Conv_1_2_5_1_2_2_0 L0_N360 L1_N63 1.5663616684e+06
R_Conv_1_2_5_1_2_2_1 L0_N361 L1_N63 2.1466641264e+05
*
R_Conv_1_2_6_0_0_0_0 L0_N248 L1_N64 3.0927915375e+05
R_Conv_1_2_6_0_0_0_1 L0_N249 L1_N64 3.6154472179e+05
R_Conv_1_2_6_0_0_1_0 L0_N250 L1_N64 1.2307612303e+05
R_Conv_1_2_6_0_0_1_1 L0_N251 L1_N64 1.3361401953e+06
R_Conv_1_2_6_0_0_2_0 L0_N252 L1_N64 1.1771240850e+06
R_Conv_1_2_6_0_0_2_1 L0_N253 L1_N64 1.1947062568e+05
R_Conv_1_2_6_0_1_0_0 L0_N304 L1_N64 3.4555602430e+05
R_Conv_1_2_6_0_1_0_1 L0_N305 L1_N64 1.2140655673e+05
R_Conv_1_2_6_0_1_1_0 L0_N306 L1_N64 2.0024008865e+05
R_Conv_1_2_6_0_1_1_1 L0_N307 L1_N64 1.3019124074e+05
R_Conv_1_2_6_0_1_2_0 L0_N308 L1_N64 1.1085089352e+05
R_Conv_1_2_6_0_1_2_1 L0_N309 L1_N64 2.5251460583e+05
R_Conv_1_2_6_0_2_0_0 L0_N360 L1_N64 1.1040315248e+05
R_Conv_1_2_6_0_2_0_1 L0_N361 L1_N64 1.2105931856e+05
R_Conv_1_2_6_0_2_1_0 L0_N362 L1_N64 1.0186236681e+05
R_Conv_1_2_6_0_2_1_1 L0_N363 L1_N64 3.8798345399e+05
R_Conv_1_2_6_0_2_2_0 L0_N364 L1_N64 4.4022254443e+06
R_Conv_1_2_6_0_2_2_1 L0_N365 L1_N64 1.5358515901e+05
*
R_Conv_1_2_6_1_0_0_0 L0_N248 L1_N65 1.2123709737e+05
R_Conv_1_2_6_1_0_0_1 L0_N249 L1_N65 1.0849154640e+05
R_Conv_1_2_6_1_0_1_0 L0_N250 L1_N65 2.0480317885e+05
R_Conv_1_2_6_1_0_1_1 L0_N251 L1_N65 1.6641635952e+05
R_Conv_1_2_6_1_0_2_0 L0_N252 L1_N65 1.1683261279e+06
R_Conv_1_2_6_1_0_2_1 L0_N253 L1_N65 1.1602008983e+05
R_Conv_1_2_6_1_1_0_0 L0_N304 L1_N65 1.2296662853e+05
R_Conv_1_2_6_1_1_0_1 L0_N305 L1_N65 1.6882235068e+05
R_Conv_1_2_6_1_1_1_0 L0_N306 L1_N65 1.0472083211e+05
R_Conv_1_2_6_1_1_1_1 L0_N307 L1_N65 2.1167619859e+05
R_Conv_1_2_6_1_1_2_0 L0_N308 L1_N65 1.3518319025e+05
R_Conv_1_2_6_1_1_2_1 L0_N309 L1_N65 1.4280846670e+05
R_Conv_1_2_6_1_2_0_0 L0_N360 L1_N65 1.1620759255e+05
R_Conv_1_2_6_1_2_0_1 L0_N361 L1_N65 1.6895116802e+05
R_Conv_1_2_6_1_2_1_0 L0_N362 L1_N65 1.2455043512e+06
R_Conv_1_2_6_1_2_1_1 L0_N363 L1_N65 1.1694022847e+05
R_Conv_1_2_6_1_2_2_0 L0_N364 L1_N65 1.5663616684e+06
R_Conv_1_2_6_1_2_2_1 L0_N365 L1_N65 2.1466641264e+05
*
R_Conv_1_2_7_0_0_0_0 L0_N252 L1_N66 3.0927915375e+05
R_Conv_1_2_7_0_0_0_1 L0_N253 L1_N66 3.6154472179e+05
R_Conv_1_2_7_0_0_1_0 L0_N254 L1_N66 1.2307612303e+05
R_Conv_1_2_7_0_0_1_1 L0_N255 L1_N66 1.3361401953e+06
R_Conv_1_2_7_0_0_2_0 L0_N256 L1_N66 1.1771240850e+06
R_Conv_1_2_7_0_0_2_1 L0_N257 L1_N66 1.1947062568e+05
R_Conv_1_2_7_0_1_0_0 L0_N308 L1_N66 3.4555602430e+05
R_Conv_1_2_7_0_1_0_1 L0_N309 L1_N66 1.2140655673e+05
R_Conv_1_2_7_0_1_1_0 L0_N310 L1_N66 2.0024008865e+05
R_Conv_1_2_7_0_1_1_1 L0_N311 L1_N66 1.3019124074e+05
R_Conv_1_2_7_0_1_2_0 L0_N312 L1_N66 1.1085089352e+05
R_Conv_1_2_7_0_1_2_1 L0_N313 L1_N66 2.5251460583e+05
R_Conv_1_2_7_0_2_0_0 L0_N364 L1_N66 1.1040315248e+05
R_Conv_1_2_7_0_2_0_1 L0_N365 L1_N66 1.2105931856e+05
R_Conv_1_2_7_0_2_1_0 L0_N366 L1_N66 1.0186236681e+05
R_Conv_1_2_7_0_2_1_1 L0_N367 L1_N66 3.8798345399e+05
R_Conv_1_2_7_0_2_2_0 L0_N368 L1_N66 4.4022254443e+06
R_Conv_1_2_7_0_2_2_1 L0_N369 L1_N66 1.5358515901e+05
*
R_Conv_1_2_7_1_0_0_0 L0_N252 L1_N67 1.2123709737e+05
R_Conv_1_2_7_1_0_0_1 L0_N253 L1_N67 1.0849154640e+05
R_Conv_1_2_7_1_0_1_0 L0_N254 L1_N67 2.0480317885e+05
R_Conv_1_2_7_1_0_1_1 L0_N255 L1_N67 1.6641635952e+05
R_Conv_1_2_7_1_0_2_0 L0_N256 L1_N67 1.1683261279e+06
R_Conv_1_2_7_1_0_2_1 L0_N257 L1_N67 1.1602008983e+05
R_Conv_1_2_7_1_1_0_0 L0_N308 L1_N67 1.2296662853e+05
R_Conv_1_2_7_1_1_0_1 L0_N309 L1_N67 1.6882235068e+05
R_Conv_1_2_7_1_1_1_0 L0_N310 L1_N67 1.0472083211e+05
R_Conv_1_2_7_1_1_1_1 L0_N311 L1_N67 2.1167619859e+05
R_Conv_1_2_7_1_1_2_0 L0_N312 L1_N67 1.3518319025e+05
R_Conv_1_2_7_1_1_2_1 L0_N313 L1_N67 1.4280846670e+05
R_Conv_1_2_7_1_2_0_0 L0_N364 L1_N67 1.1620759255e+05
R_Conv_1_2_7_1_2_0_1 L0_N365 L1_N67 1.6895116802e+05
R_Conv_1_2_7_1_2_1_0 L0_N366 L1_N67 1.2455043512e+06
R_Conv_1_2_7_1_2_1_1 L0_N367 L1_N67 1.1694022847e+05
R_Conv_1_2_7_1_2_2_0 L0_N368 L1_N67 1.5663616684e+06
R_Conv_1_2_7_1_2_2_1 L0_N369 L1_N67 2.1466641264e+05
*
R_Conv_1_2_8_0_0_0_0 L0_N256 L1_N68 3.0927915375e+05
R_Conv_1_2_8_0_0_0_1 L0_N257 L1_N68 3.6154472179e+05
R_Conv_1_2_8_0_0_1_0 L0_N258 L1_N68 1.2307612303e+05
R_Conv_1_2_8_0_0_1_1 L0_N259 L1_N68 1.3361401953e+06
R_Conv_1_2_8_0_0_2_0 L0_N260 L1_N68 1.1771240850e+06
R_Conv_1_2_8_0_0_2_1 L0_N261 L1_N68 1.1947062568e+05
R_Conv_1_2_8_0_1_0_0 L0_N312 L1_N68 3.4555602430e+05
R_Conv_1_2_8_0_1_0_1 L0_N313 L1_N68 1.2140655673e+05
R_Conv_1_2_8_0_1_1_0 L0_N314 L1_N68 2.0024008865e+05
R_Conv_1_2_8_0_1_1_1 L0_N315 L1_N68 1.3019124074e+05
R_Conv_1_2_8_0_1_2_0 L0_N316 L1_N68 1.1085089352e+05
R_Conv_1_2_8_0_1_2_1 L0_N317 L1_N68 2.5251460583e+05
R_Conv_1_2_8_0_2_0_0 L0_N368 L1_N68 1.1040315248e+05
R_Conv_1_2_8_0_2_0_1 L0_N369 L1_N68 1.2105931856e+05
R_Conv_1_2_8_0_2_1_0 L0_N370 L1_N68 1.0186236681e+05
R_Conv_1_2_8_0_2_1_1 L0_N371 L1_N68 3.8798345399e+05
R_Conv_1_2_8_0_2_2_0 L0_N372 L1_N68 4.4022254443e+06
R_Conv_1_2_8_0_2_2_1 L0_N373 L1_N68 1.5358515901e+05
*
R_Conv_1_2_8_1_0_0_0 L0_N256 L1_N69 1.2123709737e+05
R_Conv_1_2_8_1_0_0_1 L0_N257 L1_N69 1.0849154640e+05
R_Conv_1_2_8_1_0_1_0 L0_N258 L1_N69 2.0480317885e+05
R_Conv_1_2_8_1_0_1_1 L0_N259 L1_N69 1.6641635952e+05
R_Conv_1_2_8_1_0_2_0 L0_N260 L1_N69 1.1683261279e+06
R_Conv_1_2_8_1_0_2_1 L0_N261 L1_N69 1.1602008983e+05
R_Conv_1_2_8_1_1_0_0 L0_N312 L1_N69 1.2296662853e+05
R_Conv_1_2_8_1_1_0_1 L0_N313 L1_N69 1.6882235068e+05
R_Conv_1_2_8_1_1_1_0 L0_N314 L1_N69 1.0472083211e+05
R_Conv_1_2_8_1_1_1_1 L0_N315 L1_N69 2.1167619859e+05
R_Conv_1_2_8_1_1_2_0 L0_N316 L1_N69 1.3518319025e+05
R_Conv_1_2_8_1_1_2_1 L0_N317 L1_N69 1.4280846670e+05
R_Conv_1_2_8_1_2_0_0 L0_N368 L1_N69 1.1620759255e+05
R_Conv_1_2_8_1_2_0_1 L0_N369 L1_N69 1.6895116802e+05
R_Conv_1_2_8_1_2_1_0 L0_N370 L1_N69 1.2455043512e+06
R_Conv_1_2_8_1_2_1_1 L0_N371 L1_N69 1.1694022847e+05
R_Conv_1_2_8_1_2_2_0 L0_N372 L1_N69 1.5663616684e+06
R_Conv_1_2_8_1_2_2_1 L0_N373 L1_N69 2.1466641264e+05
*
R_Conv_1_2_9_0_0_0_0 L0_N260 L1_N70 3.0927915375e+05
R_Conv_1_2_9_0_0_0_1 L0_N261 L1_N70 3.6154472179e+05
R_Conv_1_2_9_0_0_1_0 L0_N262 L1_N70 1.2307612303e+05
R_Conv_1_2_9_0_0_1_1 L0_N263 L1_N70 1.3361401953e+06
R_Conv_1_2_9_0_0_2_0 L0_N264 L1_N70 1.1771240850e+06
R_Conv_1_2_9_0_0_2_1 L0_N265 L1_N70 1.1947062568e+05
R_Conv_1_2_9_0_1_0_0 L0_N316 L1_N70 3.4555602430e+05
R_Conv_1_2_9_0_1_0_1 L0_N317 L1_N70 1.2140655673e+05
R_Conv_1_2_9_0_1_1_0 L0_N318 L1_N70 2.0024008865e+05
R_Conv_1_2_9_0_1_1_1 L0_N319 L1_N70 1.3019124074e+05
R_Conv_1_2_9_0_1_2_0 L0_N320 L1_N70 1.1085089352e+05
R_Conv_1_2_9_0_1_2_1 L0_N321 L1_N70 2.5251460583e+05
R_Conv_1_2_9_0_2_0_0 L0_N372 L1_N70 1.1040315248e+05
R_Conv_1_2_9_0_2_0_1 L0_N373 L1_N70 1.2105931856e+05
R_Conv_1_2_9_0_2_1_0 L0_N374 L1_N70 1.0186236681e+05
R_Conv_1_2_9_0_2_1_1 L0_N375 L1_N70 3.8798345399e+05
R_Conv_1_2_9_0_2_2_0 L0_N376 L1_N70 4.4022254443e+06
R_Conv_1_2_9_0_2_2_1 L0_N377 L1_N70 1.5358515901e+05
*
R_Conv_1_2_9_1_0_0_0 L0_N260 L1_N71 1.2123709737e+05
R_Conv_1_2_9_1_0_0_1 L0_N261 L1_N71 1.0849154640e+05
R_Conv_1_2_9_1_0_1_0 L0_N262 L1_N71 2.0480317885e+05
R_Conv_1_2_9_1_0_1_1 L0_N263 L1_N71 1.6641635952e+05
R_Conv_1_2_9_1_0_2_0 L0_N264 L1_N71 1.1683261279e+06
R_Conv_1_2_9_1_0_2_1 L0_N265 L1_N71 1.1602008983e+05
R_Conv_1_2_9_1_1_0_0 L0_N316 L1_N71 1.2296662853e+05
R_Conv_1_2_9_1_1_0_1 L0_N317 L1_N71 1.6882235068e+05
R_Conv_1_2_9_1_1_1_0 L0_N318 L1_N71 1.0472083211e+05
R_Conv_1_2_9_1_1_1_1 L0_N319 L1_N71 2.1167619859e+05
R_Conv_1_2_9_1_1_2_0 L0_N320 L1_N71 1.3518319025e+05
R_Conv_1_2_9_1_1_2_1 L0_N321 L1_N71 1.4280846670e+05
R_Conv_1_2_9_1_2_0_0 L0_N372 L1_N71 1.1620759255e+05
R_Conv_1_2_9_1_2_0_1 L0_N373 L1_N71 1.6895116802e+05
R_Conv_1_2_9_1_2_1_0 L0_N374 L1_N71 1.2455043512e+06
R_Conv_1_2_9_1_2_1_1 L0_N375 L1_N71 1.1694022847e+05
R_Conv_1_2_9_1_2_2_0 L0_N376 L1_N71 1.5663616684e+06
R_Conv_1_2_9_1_2_2_1 L0_N377 L1_N71 2.1466641264e+05
*
R_Conv_1_2_10_0_0_0_0 L0_N264 L1_N72 3.0927915375e+05
R_Conv_1_2_10_0_0_0_1 L0_N265 L1_N72 3.6154472179e+05
R_Conv_1_2_10_0_0_1_0 L0_N266 L1_N72 1.2307612303e+05
R_Conv_1_2_10_0_0_1_1 L0_N267 L1_N72 1.3361401953e+06
R_Conv_1_2_10_0_0_2_0 L0_N268 L1_N72 1.1771240850e+06
R_Conv_1_2_10_0_0_2_1 L0_N269 L1_N72 1.1947062568e+05
R_Conv_1_2_10_0_1_0_0 L0_N320 L1_N72 3.4555602430e+05
R_Conv_1_2_10_0_1_0_1 L0_N321 L1_N72 1.2140655673e+05
R_Conv_1_2_10_0_1_1_0 L0_N322 L1_N72 2.0024008865e+05
R_Conv_1_2_10_0_1_1_1 L0_N323 L1_N72 1.3019124074e+05
R_Conv_1_2_10_0_1_2_0 L0_N324 L1_N72 1.1085089352e+05
R_Conv_1_2_10_0_1_2_1 L0_N325 L1_N72 2.5251460583e+05
R_Conv_1_2_10_0_2_0_0 L0_N376 L1_N72 1.1040315248e+05
R_Conv_1_2_10_0_2_0_1 L0_N377 L1_N72 1.2105931856e+05
R_Conv_1_2_10_0_2_1_0 L0_N378 L1_N72 1.0186236681e+05
R_Conv_1_2_10_0_2_1_1 L0_N379 L1_N72 3.8798345399e+05
R_Conv_1_2_10_0_2_2_0 L0_N380 L1_N72 4.4022254443e+06
R_Conv_1_2_10_0_2_2_1 L0_N381 L1_N72 1.5358515901e+05
*
R_Conv_1_2_10_1_0_0_0 L0_N264 L1_N73 1.2123709737e+05
R_Conv_1_2_10_1_0_0_1 L0_N265 L1_N73 1.0849154640e+05
R_Conv_1_2_10_1_0_1_0 L0_N266 L1_N73 2.0480317885e+05
R_Conv_1_2_10_1_0_1_1 L0_N267 L1_N73 1.6641635952e+05
R_Conv_1_2_10_1_0_2_0 L0_N268 L1_N73 1.1683261279e+06
R_Conv_1_2_10_1_0_2_1 L0_N269 L1_N73 1.1602008983e+05
R_Conv_1_2_10_1_1_0_0 L0_N320 L1_N73 1.2296662853e+05
R_Conv_1_2_10_1_1_0_1 L0_N321 L1_N73 1.6882235068e+05
R_Conv_1_2_10_1_1_1_0 L0_N322 L1_N73 1.0472083211e+05
R_Conv_1_2_10_1_1_1_1 L0_N323 L1_N73 2.1167619859e+05
R_Conv_1_2_10_1_1_2_0 L0_N324 L1_N73 1.3518319025e+05
R_Conv_1_2_10_1_1_2_1 L0_N325 L1_N73 1.4280846670e+05
R_Conv_1_2_10_1_2_0_0 L0_N376 L1_N73 1.1620759255e+05
R_Conv_1_2_10_1_2_0_1 L0_N377 L1_N73 1.6895116802e+05
R_Conv_1_2_10_1_2_1_0 L0_N378 L1_N73 1.2455043512e+06
R_Conv_1_2_10_1_2_1_1 L0_N379 L1_N73 1.1694022847e+05
R_Conv_1_2_10_1_2_2_0 L0_N380 L1_N73 1.5663616684e+06
R_Conv_1_2_10_1_2_2_1 L0_N381 L1_N73 2.1466641264e+05
*
R_Conv_1_2_11_0_0_0_0 L0_N268 L1_N74 3.0927915375e+05
R_Conv_1_2_11_0_0_0_1 L0_N269 L1_N74 3.6154472179e+05
R_Conv_1_2_11_0_0_1_0 L0_N270 L1_N74 1.2307612303e+05
R_Conv_1_2_11_0_0_1_1 L0_N271 L1_N74 1.3361401953e+06
R_Conv_1_2_11_0_0_2_0 L0_N272 L1_N74 1.1771240850e+06
R_Conv_1_2_11_0_0_2_1 L0_N273 L1_N74 1.1947062568e+05
R_Conv_1_2_11_0_1_0_0 L0_N324 L1_N74 3.4555602430e+05
R_Conv_1_2_11_0_1_0_1 L0_N325 L1_N74 1.2140655673e+05
R_Conv_1_2_11_0_1_1_0 L0_N326 L1_N74 2.0024008865e+05
R_Conv_1_2_11_0_1_1_1 L0_N327 L1_N74 1.3019124074e+05
R_Conv_1_2_11_0_1_2_0 L0_N328 L1_N74 1.1085089352e+05
R_Conv_1_2_11_0_1_2_1 L0_N329 L1_N74 2.5251460583e+05
R_Conv_1_2_11_0_2_0_0 L0_N380 L1_N74 1.1040315248e+05
R_Conv_1_2_11_0_2_0_1 L0_N381 L1_N74 1.2105931856e+05
R_Conv_1_2_11_0_2_1_0 L0_N382 L1_N74 1.0186236681e+05
R_Conv_1_2_11_0_2_1_1 L0_N383 L1_N74 3.8798345399e+05
R_Conv_1_2_11_0_2_2_0 L0_N384 L1_N74 4.4022254443e+06
R_Conv_1_2_11_0_2_2_1 L0_N385 L1_N74 1.5358515901e+05
*
R_Conv_1_2_11_1_0_0_0 L0_N268 L1_N75 1.2123709737e+05
R_Conv_1_2_11_1_0_0_1 L0_N269 L1_N75 1.0849154640e+05
R_Conv_1_2_11_1_0_1_0 L0_N270 L1_N75 2.0480317885e+05
R_Conv_1_2_11_1_0_1_1 L0_N271 L1_N75 1.6641635952e+05
R_Conv_1_2_11_1_0_2_0 L0_N272 L1_N75 1.1683261279e+06
R_Conv_1_2_11_1_0_2_1 L0_N273 L1_N75 1.1602008983e+05
R_Conv_1_2_11_1_1_0_0 L0_N324 L1_N75 1.2296662853e+05
R_Conv_1_2_11_1_1_0_1 L0_N325 L1_N75 1.6882235068e+05
R_Conv_1_2_11_1_1_1_0 L0_N326 L1_N75 1.0472083211e+05
R_Conv_1_2_11_1_1_1_1 L0_N327 L1_N75 2.1167619859e+05
R_Conv_1_2_11_1_1_2_0 L0_N328 L1_N75 1.3518319025e+05
R_Conv_1_2_11_1_1_2_1 L0_N329 L1_N75 1.4280846670e+05
R_Conv_1_2_11_1_2_0_0 L0_N380 L1_N75 1.1620759255e+05
R_Conv_1_2_11_1_2_0_1 L0_N381 L1_N75 1.6895116802e+05
R_Conv_1_2_11_1_2_1_0 L0_N382 L1_N75 1.2455043512e+06
R_Conv_1_2_11_1_2_1_1 L0_N383 L1_N75 1.1694022847e+05
R_Conv_1_2_11_1_2_2_0 L0_N384 L1_N75 1.5663616684e+06
R_Conv_1_2_11_1_2_2_1 L0_N385 L1_N75 2.1466641264e+05
*
R_Conv_1_2_12_0_0_0_0 L0_N272 L1_N76 3.0927915375e+05
R_Conv_1_2_12_0_0_0_1 L0_N273 L1_N76 3.6154472179e+05
R_Conv_1_2_12_0_0_1_0 L0_N274 L1_N76 1.2307612303e+05
R_Conv_1_2_12_0_0_1_1 L0_N275 L1_N76 1.3361401953e+06
R_Conv_1_2_12_0_0_2_0 L0_N276 L1_N76 1.1771240850e+06
R_Conv_1_2_12_0_0_2_1 L0_N277 L1_N76 1.1947062568e+05
R_Conv_1_2_12_0_1_0_0 L0_N328 L1_N76 3.4555602430e+05
R_Conv_1_2_12_0_1_0_1 L0_N329 L1_N76 1.2140655673e+05
R_Conv_1_2_12_0_1_1_0 L0_N330 L1_N76 2.0024008865e+05
R_Conv_1_2_12_0_1_1_1 L0_N331 L1_N76 1.3019124074e+05
R_Conv_1_2_12_0_1_2_0 L0_N332 L1_N76 1.1085089352e+05
R_Conv_1_2_12_0_1_2_1 L0_N333 L1_N76 2.5251460583e+05
R_Conv_1_2_12_0_2_0_0 L0_N384 L1_N76 1.1040315248e+05
R_Conv_1_2_12_0_2_0_1 L0_N385 L1_N76 1.2105931856e+05
R_Conv_1_2_12_0_2_1_0 L0_N386 L1_N76 1.0186236681e+05
R_Conv_1_2_12_0_2_1_1 L0_N387 L1_N76 3.8798345399e+05
R_Conv_1_2_12_0_2_2_0 L0_N388 L1_N76 4.4022254443e+06
R_Conv_1_2_12_0_2_2_1 L0_N389 L1_N76 1.5358515901e+05
*
R_Conv_1_2_12_1_0_0_0 L0_N272 L1_N77 1.2123709737e+05
R_Conv_1_2_12_1_0_0_1 L0_N273 L1_N77 1.0849154640e+05
R_Conv_1_2_12_1_0_1_0 L0_N274 L1_N77 2.0480317885e+05
R_Conv_1_2_12_1_0_1_1 L0_N275 L1_N77 1.6641635952e+05
R_Conv_1_2_12_1_0_2_0 L0_N276 L1_N77 1.1683261279e+06
R_Conv_1_2_12_1_0_2_1 L0_N277 L1_N77 1.1602008983e+05
R_Conv_1_2_12_1_1_0_0 L0_N328 L1_N77 1.2296662853e+05
R_Conv_1_2_12_1_1_0_1 L0_N329 L1_N77 1.6882235068e+05
R_Conv_1_2_12_1_1_1_0 L0_N330 L1_N77 1.0472083211e+05
R_Conv_1_2_12_1_1_1_1 L0_N331 L1_N77 2.1167619859e+05
R_Conv_1_2_12_1_1_2_0 L0_N332 L1_N77 1.3518319025e+05
R_Conv_1_2_12_1_1_2_1 L0_N333 L1_N77 1.4280846670e+05
R_Conv_1_2_12_1_2_0_0 L0_N384 L1_N77 1.1620759255e+05
R_Conv_1_2_12_1_2_0_1 L0_N385 L1_N77 1.6895116802e+05
R_Conv_1_2_12_1_2_1_0 L0_N386 L1_N77 1.2455043512e+06
R_Conv_1_2_12_1_2_1_1 L0_N387 L1_N77 1.1694022847e+05
R_Conv_1_2_12_1_2_2_0 L0_N388 L1_N77 1.5663616684e+06
R_Conv_1_2_12_1_2_2_1 L0_N389 L1_N77 2.1466641264e+05
*
R_Conv_1_3_0_0_0_0_0 L0_N336 L1_N78 3.0927915375e+05
R_Conv_1_3_0_0_0_0_1 L0_N337 L1_N78 3.6154472179e+05
R_Conv_1_3_0_0_0_1_0 L0_N338 L1_N78 1.2307612303e+05
R_Conv_1_3_0_0_0_1_1 L0_N339 L1_N78 1.3361401953e+06
R_Conv_1_3_0_0_0_2_0 L0_N340 L1_N78 1.1771240850e+06
R_Conv_1_3_0_0_0_2_1 L0_N341 L1_N78 1.1947062568e+05
R_Conv_1_3_0_0_1_0_0 L0_N392 L1_N78 3.4555602430e+05
R_Conv_1_3_0_0_1_0_1 L0_N393 L1_N78 1.2140655673e+05
R_Conv_1_3_0_0_1_1_0 L0_N394 L1_N78 2.0024008865e+05
R_Conv_1_3_0_0_1_1_1 L0_N395 L1_N78 1.3019124074e+05
R_Conv_1_3_0_0_1_2_0 L0_N396 L1_N78 1.1085089352e+05
R_Conv_1_3_0_0_1_2_1 L0_N397 L1_N78 2.5251460583e+05
R_Conv_1_3_0_0_2_0_0 L0_N448 L1_N78 1.1040315248e+05
R_Conv_1_3_0_0_2_0_1 L0_N449 L1_N78 1.2105931856e+05
R_Conv_1_3_0_0_2_1_0 L0_N450 L1_N78 1.0186236681e+05
R_Conv_1_3_0_0_2_1_1 L0_N451 L1_N78 3.8798345399e+05
R_Conv_1_3_0_0_2_2_0 L0_N452 L1_N78 4.4022254443e+06
R_Conv_1_3_0_0_2_2_1 L0_N453 L1_N78 1.5358515901e+05
*
R_Conv_1_3_0_1_0_0_0 L0_N336 L1_N79 1.2123709737e+05
R_Conv_1_3_0_1_0_0_1 L0_N337 L1_N79 1.0849154640e+05
R_Conv_1_3_0_1_0_1_0 L0_N338 L1_N79 2.0480317885e+05
R_Conv_1_3_0_1_0_1_1 L0_N339 L1_N79 1.6641635952e+05
R_Conv_1_3_0_1_0_2_0 L0_N340 L1_N79 1.1683261279e+06
R_Conv_1_3_0_1_0_2_1 L0_N341 L1_N79 1.1602008983e+05
R_Conv_1_3_0_1_1_0_0 L0_N392 L1_N79 1.2296662853e+05
R_Conv_1_3_0_1_1_0_1 L0_N393 L1_N79 1.6882235068e+05
R_Conv_1_3_0_1_1_1_0 L0_N394 L1_N79 1.0472083211e+05
R_Conv_1_3_0_1_1_1_1 L0_N395 L1_N79 2.1167619859e+05
R_Conv_1_3_0_1_1_2_0 L0_N396 L1_N79 1.3518319025e+05
R_Conv_1_3_0_1_1_2_1 L0_N397 L1_N79 1.4280846670e+05
R_Conv_1_3_0_1_2_0_0 L0_N448 L1_N79 1.1620759255e+05
R_Conv_1_3_0_1_2_0_1 L0_N449 L1_N79 1.6895116802e+05
R_Conv_1_3_0_1_2_1_0 L0_N450 L1_N79 1.2455043512e+06
R_Conv_1_3_0_1_2_1_1 L0_N451 L1_N79 1.1694022847e+05
R_Conv_1_3_0_1_2_2_0 L0_N452 L1_N79 1.5663616684e+06
R_Conv_1_3_0_1_2_2_1 L0_N453 L1_N79 2.1466641264e+05
*
R_Conv_1_3_1_0_0_0_0 L0_N340 L1_N80 3.0927915375e+05
R_Conv_1_3_1_0_0_0_1 L0_N341 L1_N80 3.6154472179e+05
R_Conv_1_3_1_0_0_1_0 L0_N342 L1_N80 1.2307612303e+05
R_Conv_1_3_1_0_0_1_1 L0_N343 L1_N80 1.3361401953e+06
R_Conv_1_3_1_0_0_2_0 L0_N344 L1_N80 1.1771240850e+06
R_Conv_1_3_1_0_0_2_1 L0_N345 L1_N80 1.1947062568e+05
R_Conv_1_3_1_0_1_0_0 L0_N396 L1_N80 3.4555602430e+05
R_Conv_1_3_1_0_1_0_1 L0_N397 L1_N80 1.2140655673e+05
R_Conv_1_3_1_0_1_1_0 L0_N398 L1_N80 2.0024008865e+05
R_Conv_1_3_1_0_1_1_1 L0_N399 L1_N80 1.3019124074e+05
R_Conv_1_3_1_0_1_2_0 L0_N400 L1_N80 1.1085089352e+05
R_Conv_1_3_1_0_1_2_1 L0_N401 L1_N80 2.5251460583e+05
R_Conv_1_3_1_0_2_0_0 L0_N452 L1_N80 1.1040315248e+05
R_Conv_1_3_1_0_2_0_1 L0_N453 L1_N80 1.2105931856e+05
R_Conv_1_3_1_0_2_1_0 L0_N454 L1_N80 1.0186236681e+05
R_Conv_1_3_1_0_2_1_1 L0_N455 L1_N80 3.8798345399e+05
R_Conv_1_3_1_0_2_2_0 L0_N456 L1_N80 4.4022254443e+06
R_Conv_1_3_1_0_2_2_1 L0_N457 L1_N80 1.5358515901e+05
*
R_Conv_1_3_1_1_0_0_0 L0_N340 L1_N81 1.2123709737e+05
R_Conv_1_3_1_1_0_0_1 L0_N341 L1_N81 1.0849154640e+05
R_Conv_1_3_1_1_0_1_0 L0_N342 L1_N81 2.0480317885e+05
R_Conv_1_3_1_1_0_1_1 L0_N343 L1_N81 1.6641635952e+05
R_Conv_1_3_1_1_0_2_0 L0_N344 L1_N81 1.1683261279e+06
R_Conv_1_3_1_1_0_2_1 L0_N345 L1_N81 1.1602008983e+05
R_Conv_1_3_1_1_1_0_0 L0_N396 L1_N81 1.2296662853e+05
R_Conv_1_3_1_1_1_0_1 L0_N397 L1_N81 1.6882235068e+05
R_Conv_1_3_1_1_1_1_0 L0_N398 L1_N81 1.0472083211e+05
R_Conv_1_3_1_1_1_1_1 L0_N399 L1_N81 2.1167619859e+05
R_Conv_1_3_1_1_1_2_0 L0_N400 L1_N81 1.3518319025e+05
R_Conv_1_3_1_1_1_2_1 L0_N401 L1_N81 1.4280846670e+05
R_Conv_1_3_1_1_2_0_0 L0_N452 L1_N81 1.1620759255e+05
R_Conv_1_3_1_1_2_0_1 L0_N453 L1_N81 1.6895116802e+05
R_Conv_1_3_1_1_2_1_0 L0_N454 L1_N81 1.2455043512e+06
R_Conv_1_3_1_1_2_1_1 L0_N455 L1_N81 1.1694022847e+05
R_Conv_1_3_1_1_2_2_0 L0_N456 L1_N81 1.5663616684e+06
R_Conv_1_3_1_1_2_2_1 L0_N457 L1_N81 2.1466641264e+05
*
R_Conv_1_3_2_0_0_0_0 L0_N344 L1_N82 3.0927915375e+05
R_Conv_1_3_2_0_0_0_1 L0_N345 L1_N82 3.6154472179e+05
R_Conv_1_3_2_0_0_1_0 L0_N346 L1_N82 1.2307612303e+05
R_Conv_1_3_2_0_0_1_1 L0_N347 L1_N82 1.3361401953e+06
R_Conv_1_3_2_0_0_2_0 L0_N348 L1_N82 1.1771240850e+06
R_Conv_1_3_2_0_0_2_1 L0_N349 L1_N82 1.1947062568e+05
R_Conv_1_3_2_0_1_0_0 L0_N400 L1_N82 3.4555602430e+05
R_Conv_1_3_2_0_1_0_1 L0_N401 L1_N82 1.2140655673e+05
R_Conv_1_3_2_0_1_1_0 L0_N402 L1_N82 2.0024008865e+05
R_Conv_1_3_2_0_1_1_1 L0_N403 L1_N82 1.3019124074e+05
R_Conv_1_3_2_0_1_2_0 L0_N404 L1_N82 1.1085089352e+05
R_Conv_1_3_2_0_1_2_1 L0_N405 L1_N82 2.5251460583e+05
R_Conv_1_3_2_0_2_0_0 L0_N456 L1_N82 1.1040315248e+05
R_Conv_1_3_2_0_2_0_1 L0_N457 L1_N82 1.2105931856e+05
R_Conv_1_3_2_0_2_1_0 L0_N458 L1_N82 1.0186236681e+05
R_Conv_1_3_2_0_2_1_1 L0_N459 L1_N82 3.8798345399e+05
R_Conv_1_3_2_0_2_2_0 L0_N460 L1_N82 4.4022254443e+06
R_Conv_1_3_2_0_2_2_1 L0_N461 L1_N82 1.5358515901e+05
*
R_Conv_1_3_2_1_0_0_0 L0_N344 L1_N83 1.2123709737e+05
R_Conv_1_3_2_1_0_0_1 L0_N345 L1_N83 1.0849154640e+05
R_Conv_1_3_2_1_0_1_0 L0_N346 L1_N83 2.0480317885e+05
R_Conv_1_3_2_1_0_1_1 L0_N347 L1_N83 1.6641635952e+05
R_Conv_1_3_2_1_0_2_0 L0_N348 L1_N83 1.1683261279e+06
R_Conv_1_3_2_1_0_2_1 L0_N349 L1_N83 1.1602008983e+05
R_Conv_1_3_2_1_1_0_0 L0_N400 L1_N83 1.2296662853e+05
R_Conv_1_3_2_1_1_0_1 L0_N401 L1_N83 1.6882235068e+05
R_Conv_1_3_2_1_1_1_0 L0_N402 L1_N83 1.0472083211e+05
R_Conv_1_3_2_1_1_1_1 L0_N403 L1_N83 2.1167619859e+05
R_Conv_1_3_2_1_1_2_0 L0_N404 L1_N83 1.3518319025e+05
R_Conv_1_3_2_1_1_2_1 L0_N405 L1_N83 1.4280846670e+05
R_Conv_1_3_2_1_2_0_0 L0_N456 L1_N83 1.1620759255e+05
R_Conv_1_3_2_1_2_0_1 L0_N457 L1_N83 1.6895116802e+05
R_Conv_1_3_2_1_2_1_0 L0_N458 L1_N83 1.2455043512e+06
R_Conv_1_3_2_1_2_1_1 L0_N459 L1_N83 1.1694022847e+05
R_Conv_1_3_2_1_2_2_0 L0_N460 L1_N83 1.5663616684e+06
R_Conv_1_3_2_1_2_2_1 L0_N461 L1_N83 2.1466641264e+05
*
R_Conv_1_3_3_0_0_0_0 L0_N348 L1_N84 3.0927915375e+05
R_Conv_1_3_3_0_0_0_1 L0_N349 L1_N84 3.6154472179e+05
R_Conv_1_3_3_0_0_1_0 L0_N350 L1_N84 1.2307612303e+05
R_Conv_1_3_3_0_0_1_1 L0_N351 L1_N84 1.3361401953e+06
R_Conv_1_3_3_0_0_2_0 L0_N352 L1_N84 1.1771240850e+06
R_Conv_1_3_3_0_0_2_1 L0_N353 L1_N84 1.1947062568e+05
R_Conv_1_3_3_0_1_0_0 L0_N404 L1_N84 3.4555602430e+05
R_Conv_1_3_3_0_1_0_1 L0_N405 L1_N84 1.2140655673e+05
R_Conv_1_3_3_0_1_1_0 L0_N406 L1_N84 2.0024008865e+05
R_Conv_1_3_3_0_1_1_1 L0_N407 L1_N84 1.3019124074e+05
R_Conv_1_3_3_0_1_2_0 L0_N408 L1_N84 1.1085089352e+05
R_Conv_1_3_3_0_1_2_1 L0_N409 L1_N84 2.5251460583e+05
R_Conv_1_3_3_0_2_0_0 L0_N460 L1_N84 1.1040315248e+05
R_Conv_1_3_3_0_2_0_1 L0_N461 L1_N84 1.2105931856e+05
R_Conv_1_3_3_0_2_1_0 L0_N462 L1_N84 1.0186236681e+05
R_Conv_1_3_3_0_2_1_1 L0_N463 L1_N84 3.8798345399e+05
R_Conv_1_3_3_0_2_2_0 L0_N464 L1_N84 4.4022254443e+06
R_Conv_1_3_3_0_2_2_1 L0_N465 L1_N84 1.5358515901e+05
*
R_Conv_1_3_3_1_0_0_0 L0_N348 L1_N85 1.2123709737e+05
R_Conv_1_3_3_1_0_0_1 L0_N349 L1_N85 1.0849154640e+05
R_Conv_1_3_3_1_0_1_0 L0_N350 L1_N85 2.0480317885e+05
R_Conv_1_3_3_1_0_1_1 L0_N351 L1_N85 1.6641635952e+05
R_Conv_1_3_3_1_0_2_0 L0_N352 L1_N85 1.1683261279e+06
R_Conv_1_3_3_1_0_2_1 L0_N353 L1_N85 1.1602008983e+05
R_Conv_1_3_3_1_1_0_0 L0_N404 L1_N85 1.2296662853e+05
R_Conv_1_3_3_1_1_0_1 L0_N405 L1_N85 1.6882235068e+05
R_Conv_1_3_3_1_1_1_0 L0_N406 L1_N85 1.0472083211e+05
R_Conv_1_3_3_1_1_1_1 L0_N407 L1_N85 2.1167619859e+05
R_Conv_1_3_3_1_1_2_0 L0_N408 L1_N85 1.3518319025e+05
R_Conv_1_3_3_1_1_2_1 L0_N409 L1_N85 1.4280846670e+05
R_Conv_1_3_3_1_2_0_0 L0_N460 L1_N85 1.1620759255e+05
R_Conv_1_3_3_1_2_0_1 L0_N461 L1_N85 1.6895116802e+05
R_Conv_1_3_3_1_2_1_0 L0_N462 L1_N85 1.2455043512e+06
R_Conv_1_3_3_1_2_1_1 L0_N463 L1_N85 1.1694022847e+05
R_Conv_1_3_3_1_2_2_0 L0_N464 L1_N85 1.5663616684e+06
R_Conv_1_3_3_1_2_2_1 L0_N465 L1_N85 2.1466641264e+05
*
R_Conv_1_3_4_0_0_0_0 L0_N352 L1_N86 3.0927915375e+05
R_Conv_1_3_4_0_0_0_1 L0_N353 L1_N86 3.6154472179e+05
R_Conv_1_3_4_0_0_1_0 L0_N354 L1_N86 1.2307612303e+05
R_Conv_1_3_4_0_0_1_1 L0_N355 L1_N86 1.3361401953e+06
R_Conv_1_3_4_0_0_2_0 L0_N356 L1_N86 1.1771240850e+06
R_Conv_1_3_4_0_0_2_1 L0_N357 L1_N86 1.1947062568e+05
R_Conv_1_3_4_0_1_0_0 L0_N408 L1_N86 3.4555602430e+05
R_Conv_1_3_4_0_1_0_1 L0_N409 L1_N86 1.2140655673e+05
R_Conv_1_3_4_0_1_1_0 L0_N410 L1_N86 2.0024008865e+05
R_Conv_1_3_4_0_1_1_1 L0_N411 L1_N86 1.3019124074e+05
R_Conv_1_3_4_0_1_2_0 L0_N412 L1_N86 1.1085089352e+05
R_Conv_1_3_4_0_1_2_1 L0_N413 L1_N86 2.5251460583e+05
R_Conv_1_3_4_0_2_0_0 L0_N464 L1_N86 1.1040315248e+05
R_Conv_1_3_4_0_2_0_1 L0_N465 L1_N86 1.2105931856e+05
R_Conv_1_3_4_0_2_1_0 L0_N466 L1_N86 1.0186236681e+05
R_Conv_1_3_4_0_2_1_1 L0_N467 L1_N86 3.8798345399e+05
R_Conv_1_3_4_0_2_2_0 L0_N468 L1_N86 4.4022254443e+06
R_Conv_1_3_4_0_2_2_1 L0_N469 L1_N86 1.5358515901e+05
*
R_Conv_1_3_4_1_0_0_0 L0_N352 L1_N87 1.2123709737e+05
R_Conv_1_3_4_1_0_0_1 L0_N353 L1_N87 1.0849154640e+05
R_Conv_1_3_4_1_0_1_0 L0_N354 L1_N87 2.0480317885e+05
R_Conv_1_3_4_1_0_1_1 L0_N355 L1_N87 1.6641635952e+05
R_Conv_1_3_4_1_0_2_0 L0_N356 L1_N87 1.1683261279e+06
R_Conv_1_3_4_1_0_2_1 L0_N357 L1_N87 1.1602008983e+05
R_Conv_1_3_4_1_1_0_0 L0_N408 L1_N87 1.2296662853e+05
R_Conv_1_3_4_1_1_0_1 L0_N409 L1_N87 1.6882235068e+05
R_Conv_1_3_4_1_1_1_0 L0_N410 L1_N87 1.0472083211e+05
R_Conv_1_3_4_1_1_1_1 L0_N411 L1_N87 2.1167619859e+05
R_Conv_1_3_4_1_1_2_0 L0_N412 L1_N87 1.3518319025e+05
R_Conv_1_3_4_1_1_2_1 L0_N413 L1_N87 1.4280846670e+05
R_Conv_1_3_4_1_2_0_0 L0_N464 L1_N87 1.1620759255e+05
R_Conv_1_3_4_1_2_0_1 L0_N465 L1_N87 1.6895116802e+05
R_Conv_1_3_4_1_2_1_0 L0_N466 L1_N87 1.2455043512e+06
R_Conv_1_3_4_1_2_1_1 L0_N467 L1_N87 1.1694022847e+05
R_Conv_1_3_4_1_2_2_0 L0_N468 L1_N87 1.5663616684e+06
R_Conv_1_3_4_1_2_2_1 L0_N469 L1_N87 2.1466641264e+05
*
R_Conv_1_3_5_0_0_0_0 L0_N356 L1_N88 3.0927915375e+05
R_Conv_1_3_5_0_0_0_1 L0_N357 L1_N88 3.6154472179e+05
R_Conv_1_3_5_0_0_1_0 L0_N358 L1_N88 1.2307612303e+05
R_Conv_1_3_5_0_0_1_1 L0_N359 L1_N88 1.3361401953e+06
R_Conv_1_3_5_0_0_2_0 L0_N360 L1_N88 1.1771240850e+06
R_Conv_1_3_5_0_0_2_1 L0_N361 L1_N88 1.1947062568e+05
R_Conv_1_3_5_0_1_0_0 L0_N412 L1_N88 3.4555602430e+05
R_Conv_1_3_5_0_1_0_1 L0_N413 L1_N88 1.2140655673e+05
R_Conv_1_3_5_0_1_1_0 L0_N414 L1_N88 2.0024008865e+05
R_Conv_1_3_5_0_1_1_1 L0_N415 L1_N88 1.3019124074e+05
R_Conv_1_3_5_0_1_2_0 L0_N416 L1_N88 1.1085089352e+05
R_Conv_1_3_5_0_1_2_1 L0_N417 L1_N88 2.5251460583e+05
R_Conv_1_3_5_0_2_0_0 L0_N468 L1_N88 1.1040315248e+05
R_Conv_1_3_5_0_2_0_1 L0_N469 L1_N88 1.2105931856e+05
R_Conv_1_3_5_0_2_1_0 L0_N470 L1_N88 1.0186236681e+05
R_Conv_1_3_5_0_2_1_1 L0_N471 L1_N88 3.8798345399e+05
R_Conv_1_3_5_0_2_2_0 L0_N472 L1_N88 4.4022254443e+06
R_Conv_1_3_5_0_2_2_1 L0_N473 L1_N88 1.5358515901e+05
*
R_Conv_1_3_5_1_0_0_0 L0_N356 L1_N89 1.2123709737e+05
R_Conv_1_3_5_1_0_0_1 L0_N357 L1_N89 1.0849154640e+05
R_Conv_1_3_5_1_0_1_0 L0_N358 L1_N89 2.0480317885e+05
R_Conv_1_3_5_1_0_1_1 L0_N359 L1_N89 1.6641635952e+05
R_Conv_1_3_5_1_0_2_0 L0_N360 L1_N89 1.1683261279e+06
R_Conv_1_3_5_1_0_2_1 L0_N361 L1_N89 1.1602008983e+05
R_Conv_1_3_5_1_1_0_0 L0_N412 L1_N89 1.2296662853e+05
R_Conv_1_3_5_1_1_0_1 L0_N413 L1_N89 1.6882235068e+05
R_Conv_1_3_5_1_1_1_0 L0_N414 L1_N89 1.0472083211e+05
R_Conv_1_3_5_1_1_1_1 L0_N415 L1_N89 2.1167619859e+05
R_Conv_1_3_5_1_1_2_0 L0_N416 L1_N89 1.3518319025e+05
R_Conv_1_3_5_1_1_2_1 L0_N417 L1_N89 1.4280846670e+05
R_Conv_1_3_5_1_2_0_0 L0_N468 L1_N89 1.1620759255e+05
R_Conv_1_3_5_1_2_0_1 L0_N469 L1_N89 1.6895116802e+05
R_Conv_1_3_5_1_2_1_0 L0_N470 L1_N89 1.2455043512e+06
R_Conv_1_3_5_1_2_1_1 L0_N471 L1_N89 1.1694022847e+05
R_Conv_1_3_5_1_2_2_0 L0_N472 L1_N89 1.5663616684e+06
R_Conv_1_3_5_1_2_2_1 L0_N473 L1_N89 2.1466641264e+05
*
R_Conv_1_3_6_0_0_0_0 L0_N360 L1_N90 3.0927915375e+05
R_Conv_1_3_6_0_0_0_1 L0_N361 L1_N90 3.6154472179e+05
R_Conv_1_3_6_0_0_1_0 L0_N362 L1_N90 1.2307612303e+05
R_Conv_1_3_6_0_0_1_1 L0_N363 L1_N90 1.3361401953e+06
R_Conv_1_3_6_0_0_2_0 L0_N364 L1_N90 1.1771240850e+06
R_Conv_1_3_6_0_0_2_1 L0_N365 L1_N90 1.1947062568e+05
R_Conv_1_3_6_0_1_0_0 L0_N416 L1_N90 3.4555602430e+05
R_Conv_1_3_6_0_1_0_1 L0_N417 L1_N90 1.2140655673e+05
R_Conv_1_3_6_0_1_1_0 L0_N418 L1_N90 2.0024008865e+05
R_Conv_1_3_6_0_1_1_1 L0_N419 L1_N90 1.3019124074e+05
R_Conv_1_3_6_0_1_2_0 L0_N420 L1_N90 1.1085089352e+05
R_Conv_1_3_6_0_1_2_1 L0_N421 L1_N90 2.5251460583e+05
R_Conv_1_3_6_0_2_0_0 L0_N472 L1_N90 1.1040315248e+05
R_Conv_1_3_6_0_2_0_1 L0_N473 L1_N90 1.2105931856e+05
R_Conv_1_3_6_0_2_1_0 L0_N474 L1_N90 1.0186236681e+05
R_Conv_1_3_6_0_2_1_1 L0_N475 L1_N90 3.8798345399e+05
R_Conv_1_3_6_0_2_2_0 L0_N476 L1_N90 4.4022254443e+06
R_Conv_1_3_6_0_2_2_1 L0_N477 L1_N90 1.5358515901e+05
*
R_Conv_1_3_6_1_0_0_0 L0_N360 L1_N91 1.2123709737e+05
R_Conv_1_3_6_1_0_0_1 L0_N361 L1_N91 1.0849154640e+05
R_Conv_1_3_6_1_0_1_0 L0_N362 L1_N91 2.0480317885e+05
R_Conv_1_3_6_1_0_1_1 L0_N363 L1_N91 1.6641635952e+05
R_Conv_1_3_6_1_0_2_0 L0_N364 L1_N91 1.1683261279e+06
R_Conv_1_3_6_1_0_2_1 L0_N365 L1_N91 1.1602008983e+05
R_Conv_1_3_6_1_1_0_0 L0_N416 L1_N91 1.2296662853e+05
R_Conv_1_3_6_1_1_0_1 L0_N417 L1_N91 1.6882235068e+05
R_Conv_1_3_6_1_1_1_0 L0_N418 L1_N91 1.0472083211e+05
R_Conv_1_3_6_1_1_1_1 L0_N419 L1_N91 2.1167619859e+05
R_Conv_1_3_6_1_1_2_0 L0_N420 L1_N91 1.3518319025e+05
R_Conv_1_3_6_1_1_2_1 L0_N421 L1_N91 1.4280846670e+05
R_Conv_1_3_6_1_2_0_0 L0_N472 L1_N91 1.1620759255e+05
R_Conv_1_3_6_1_2_0_1 L0_N473 L1_N91 1.6895116802e+05
R_Conv_1_3_6_1_2_1_0 L0_N474 L1_N91 1.2455043512e+06
R_Conv_1_3_6_1_2_1_1 L0_N475 L1_N91 1.1694022847e+05
R_Conv_1_3_6_1_2_2_0 L0_N476 L1_N91 1.5663616684e+06
R_Conv_1_3_6_1_2_2_1 L0_N477 L1_N91 2.1466641264e+05
*
R_Conv_1_3_7_0_0_0_0 L0_N364 L1_N92 3.0927915375e+05
R_Conv_1_3_7_0_0_0_1 L0_N365 L1_N92 3.6154472179e+05
R_Conv_1_3_7_0_0_1_0 L0_N366 L1_N92 1.2307612303e+05
R_Conv_1_3_7_0_0_1_1 L0_N367 L1_N92 1.3361401953e+06
R_Conv_1_3_7_0_0_2_0 L0_N368 L1_N92 1.1771240850e+06
R_Conv_1_3_7_0_0_2_1 L0_N369 L1_N92 1.1947062568e+05
R_Conv_1_3_7_0_1_0_0 L0_N420 L1_N92 3.4555602430e+05
R_Conv_1_3_7_0_1_0_1 L0_N421 L1_N92 1.2140655673e+05
R_Conv_1_3_7_0_1_1_0 L0_N422 L1_N92 2.0024008865e+05
R_Conv_1_3_7_0_1_1_1 L0_N423 L1_N92 1.3019124074e+05
R_Conv_1_3_7_0_1_2_0 L0_N424 L1_N92 1.1085089352e+05
R_Conv_1_3_7_0_1_2_1 L0_N425 L1_N92 2.5251460583e+05
R_Conv_1_3_7_0_2_0_0 L0_N476 L1_N92 1.1040315248e+05
R_Conv_1_3_7_0_2_0_1 L0_N477 L1_N92 1.2105931856e+05
R_Conv_1_3_7_0_2_1_0 L0_N478 L1_N92 1.0186236681e+05
R_Conv_1_3_7_0_2_1_1 L0_N479 L1_N92 3.8798345399e+05
R_Conv_1_3_7_0_2_2_0 L0_N480 L1_N92 4.4022254443e+06
R_Conv_1_3_7_0_2_2_1 L0_N481 L1_N92 1.5358515901e+05
*
R_Conv_1_3_7_1_0_0_0 L0_N364 L1_N93 1.2123709737e+05
R_Conv_1_3_7_1_0_0_1 L0_N365 L1_N93 1.0849154640e+05
R_Conv_1_3_7_1_0_1_0 L0_N366 L1_N93 2.0480317885e+05
R_Conv_1_3_7_1_0_1_1 L0_N367 L1_N93 1.6641635952e+05
R_Conv_1_3_7_1_0_2_0 L0_N368 L1_N93 1.1683261279e+06
R_Conv_1_3_7_1_0_2_1 L0_N369 L1_N93 1.1602008983e+05
R_Conv_1_3_7_1_1_0_0 L0_N420 L1_N93 1.2296662853e+05
R_Conv_1_3_7_1_1_0_1 L0_N421 L1_N93 1.6882235068e+05
R_Conv_1_3_7_1_1_1_0 L0_N422 L1_N93 1.0472083211e+05
R_Conv_1_3_7_1_1_1_1 L0_N423 L1_N93 2.1167619859e+05
R_Conv_1_3_7_1_1_2_0 L0_N424 L1_N93 1.3518319025e+05
R_Conv_1_3_7_1_1_2_1 L0_N425 L1_N93 1.4280846670e+05
R_Conv_1_3_7_1_2_0_0 L0_N476 L1_N93 1.1620759255e+05
R_Conv_1_3_7_1_2_0_1 L0_N477 L1_N93 1.6895116802e+05
R_Conv_1_3_7_1_2_1_0 L0_N478 L1_N93 1.2455043512e+06
R_Conv_1_3_7_1_2_1_1 L0_N479 L1_N93 1.1694022847e+05
R_Conv_1_3_7_1_2_2_0 L0_N480 L1_N93 1.5663616684e+06
R_Conv_1_3_7_1_2_2_1 L0_N481 L1_N93 2.1466641264e+05
*
R_Conv_1_3_8_0_0_0_0 L0_N368 L1_N94 3.0927915375e+05
R_Conv_1_3_8_0_0_0_1 L0_N369 L1_N94 3.6154472179e+05
R_Conv_1_3_8_0_0_1_0 L0_N370 L1_N94 1.2307612303e+05
R_Conv_1_3_8_0_0_1_1 L0_N371 L1_N94 1.3361401953e+06
R_Conv_1_3_8_0_0_2_0 L0_N372 L1_N94 1.1771240850e+06
R_Conv_1_3_8_0_0_2_1 L0_N373 L1_N94 1.1947062568e+05
R_Conv_1_3_8_0_1_0_0 L0_N424 L1_N94 3.4555602430e+05
R_Conv_1_3_8_0_1_0_1 L0_N425 L1_N94 1.2140655673e+05
R_Conv_1_3_8_0_1_1_0 L0_N426 L1_N94 2.0024008865e+05
R_Conv_1_3_8_0_1_1_1 L0_N427 L1_N94 1.3019124074e+05
R_Conv_1_3_8_0_1_2_0 L0_N428 L1_N94 1.1085089352e+05
R_Conv_1_3_8_0_1_2_1 L0_N429 L1_N94 2.5251460583e+05
R_Conv_1_3_8_0_2_0_0 L0_N480 L1_N94 1.1040315248e+05
R_Conv_1_3_8_0_2_0_1 L0_N481 L1_N94 1.2105931856e+05
R_Conv_1_3_8_0_2_1_0 L0_N482 L1_N94 1.0186236681e+05
R_Conv_1_3_8_0_2_1_1 L0_N483 L1_N94 3.8798345399e+05
R_Conv_1_3_8_0_2_2_0 L0_N484 L1_N94 4.4022254443e+06
R_Conv_1_3_8_0_2_2_1 L0_N485 L1_N94 1.5358515901e+05
*
R_Conv_1_3_8_1_0_0_0 L0_N368 L1_N95 1.2123709737e+05
R_Conv_1_3_8_1_0_0_1 L0_N369 L1_N95 1.0849154640e+05
R_Conv_1_3_8_1_0_1_0 L0_N370 L1_N95 2.0480317885e+05
R_Conv_1_3_8_1_0_1_1 L0_N371 L1_N95 1.6641635952e+05
R_Conv_1_3_8_1_0_2_0 L0_N372 L1_N95 1.1683261279e+06
R_Conv_1_3_8_1_0_2_1 L0_N373 L1_N95 1.1602008983e+05
R_Conv_1_3_8_1_1_0_0 L0_N424 L1_N95 1.2296662853e+05
R_Conv_1_3_8_1_1_0_1 L0_N425 L1_N95 1.6882235068e+05
R_Conv_1_3_8_1_1_1_0 L0_N426 L1_N95 1.0472083211e+05
R_Conv_1_3_8_1_1_1_1 L0_N427 L1_N95 2.1167619859e+05
R_Conv_1_3_8_1_1_2_0 L0_N428 L1_N95 1.3518319025e+05
R_Conv_1_3_8_1_1_2_1 L0_N429 L1_N95 1.4280846670e+05
R_Conv_1_3_8_1_2_0_0 L0_N480 L1_N95 1.1620759255e+05
R_Conv_1_3_8_1_2_0_1 L0_N481 L1_N95 1.6895116802e+05
R_Conv_1_3_8_1_2_1_0 L0_N482 L1_N95 1.2455043512e+06
R_Conv_1_3_8_1_2_1_1 L0_N483 L1_N95 1.1694022847e+05
R_Conv_1_3_8_1_2_2_0 L0_N484 L1_N95 1.5663616684e+06
R_Conv_1_3_8_1_2_2_1 L0_N485 L1_N95 2.1466641264e+05
*
R_Conv_1_3_9_0_0_0_0 L0_N372 L1_N96 3.0927915375e+05
R_Conv_1_3_9_0_0_0_1 L0_N373 L1_N96 3.6154472179e+05
R_Conv_1_3_9_0_0_1_0 L0_N374 L1_N96 1.2307612303e+05
R_Conv_1_3_9_0_0_1_1 L0_N375 L1_N96 1.3361401953e+06
R_Conv_1_3_9_0_0_2_0 L0_N376 L1_N96 1.1771240850e+06
R_Conv_1_3_9_0_0_2_1 L0_N377 L1_N96 1.1947062568e+05
R_Conv_1_3_9_0_1_0_0 L0_N428 L1_N96 3.4555602430e+05
R_Conv_1_3_9_0_1_0_1 L0_N429 L1_N96 1.2140655673e+05
R_Conv_1_3_9_0_1_1_0 L0_N430 L1_N96 2.0024008865e+05
R_Conv_1_3_9_0_1_1_1 L0_N431 L1_N96 1.3019124074e+05
R_Conv_1_3_9_0_1_2_0 L0_N432 L1_N96 1.1085089352e+05
R_Conv_1_3_9_0_1_2_1 L0_N433 L1_N96 2.5251460583e+05
R_Conv_1_3_9_0_2_0_0 L0_N484 L1_N96 1.1040315248e+05
R_Conv_1_3_9_0_2_0_1 L0_N485 L1_N96 1.2105931856e+05
R_Conv_1_3_9_0_2_1_0 L0_N486 L1_N96 1.0186236681e+05
R_Conv_1_3_9_0_2_1_1 L0_N487 L1_N96 3.8798345399e+05
R_Conv_1_3_9_0_2_2_0 L0_N488 L1_N96 4.4022254443e+06
R_Conv_1_3_9_0_2_2_1 L0_N489 L1_N96 1.5358515901e+05
*
R_Conv_1_3_9_1_0_0_0 L0_N372 L1_N97 1.2123709737e+05
R_Conv_1_3_9_1_0_0_1 L0_N373 L1_N97 1.0849154640e+05
R_Conv_1_3_9_1_0_1_0 L0_N374 L1_N97 2.0480317885e+05
R_Conv_1_3_9_1_0_1_1 L0_N375 L1_N97 1.6641635952e+05
R_Conv_1_3_9_1_0_2_0 L0_N376 L1_N97 1.1683261279e+06
R_Conv_1_3_9_1_0_2_1 L0_N377 L1_N97 1.1602008983e+05
R_Conv_1_3_9_1_1_0_0 L0_N428 L1_N97 1.2296662853e+05
R_Conv_1_3_9_1_1_0_1 L0_N429 L1_N97 1.6882235068e+05
R_Conv_1_3_9_1_1_1_0 L0_N430 L1_N97 1.0472083211e+05
R_Conv_1_3_9_1_1_1_1 L0_N431 L1_N97 2.1167619859e+05
R_Conv_1_3_9_1_1_2_0 L0_N432 L1_N97 1.3518319025e+05
R_Conv_1_3_9_1_1_2_1 L0_N433 L1_N97 1.4280846670e+05
R_Conv_1_3_9_1_2_0_0 L0_N484 L1_N97 1.1620759255e+05
R_Conv_1_3_9_1_2_0_1 L0_N485 L1_N97 1.6895116802e+05
R_Conv_1_3_9_1_2_1_0 L0_N486 L1_N97 1.2455043512e+06
R_Conv_1_3_9_1_2_1_1 L0_N487 L1_N97 1.1694022847e+05
R_Conv_1_3_9_1_2_2_0 L0_N488 L1_N97 1.5663616684e+06
R_Conv_1_3_9_1_2_2_1 L0_N489 L1_N97 2.1466641264e+05
*
R_Conv_1_3_10_0_0_0_0 L0_N376 L1_N98 3.0927915375e+05
R_Conv_1_3_10_0_0_0_1 L0_N377 L1_N98 3.6154472179e+05
R_Conv_1_3_10_0_0_1_0 L0_N378 L1_N98 1.2307612303e+05
R_Conv_1_3_10_0_0_1_1 L0_N379 L1_N98 1.3361401953e+06
R_Conv_1_3_10_0_0_2_0 L0_N380 L1_N98 1.1771240850e+06
R_Conv_1_3_10_0_0_2_1 L0_N381 L1_N98 1.1947062568e+05
R_Conv_1_3_10_0_1_0_0 L0_N432 L1_N98 3.4555602430e+05
R_Conv_1_3_10_0_1_0_1 L0_N433 L1_N98 1.2140655673e+05
R_Conv_1_3_10_0_1_1_0 L0_N434 L1_N98 2.0024008865e+05
R_Conv_1_3_10_0_1_1_1 L0_N435 L1_N98 1.3019124074e+05
R_Conv_1_3_10_0_1_2_0 L0_N436 L1_N98 1.1085089352e+05
R_Conv_1_3_10_0_1_2_1 L0_N437 L1_N98 2.5251460583e+05
R_Conv_1_3_10_0_2_0_0 L0_N488 L1_N98 1.1040315248e+05
R_Conv_1_3_10_0_2_0_1 L0_N489 L1_N98 1.2105931856e+05
R_Conv_1_3_10_0_2_1_0 L0_N490 L1_N98 1.0186236681e+05
R_Conv_1_3_10_0_2_1_1 L0_N491 L1_N98 3.8798345399e+05
R_Conv_1_3_10_0_2_2_0 L0_N492 L1_N98 4.4022254443e+06
R_Conv_1_3_10_0_2_2_1 L0_N493 L1_N98 1.5358515901e+05
*
R_Conv_1_3_10_1_0_0_0 L0_N376 L1_N99 1.2123709737e+05
R_Conv_1_3_10_1_0_0_1 L0_N377 L1_N99 1.0849154640e+05
R_Conv_1_3_10_1_0_1_0 L0_N378 L1_N99 2.0480317885e+05
R_Conv_1_3_10_1_0_1_1 L0_N379 L1_N99 1.6641635952e+05
R_Conv_1_3_10_1_0_2_0 L0_N380 L1_N99 1.1683261279e+06
R_Conv_1_3_10_1_0_2_1 L0_N381 L1_N99 1.1602008983e+05
R_Conv_1_3_10_1_1_0_0 L0_N432 L1_N99 1.2296662853e+05
R_Conv_1_3_10_1_1_0_1 L0_N433 L1_N99 1.6882235068e+05
R_Conv_1_3_10_1_1_1_0 L0_N434 L1_N99 1.0472083211e+05
R_Conv_1_3_10_1_1_1_1 L0_N435 L1_N99 2.1167619859e+05
R_Conv_1_3_10_1_1_2_0 L0_N436 L1_N99 1.3518319025e+05
R_Conv_1_3_10_1_1_2_1 L0_N437 L1_N99 1.4280846670e+05
R_Conv_1_3_10_1_2_0_0 L0_N488 L1_N99 1.1620759255e+05
R_Conv_1_3_10_1_2_0_1 L0_N489 L1_N99 1.6895116802e+05
R_Conv_1_3_10_1_2_1_0 L0_N490 L1_N99 1.2455043512e+06
R_Conv_1_3_10_1_2_1_1 L0_N491 L1_N99 1.1694022847e+05
R_Conv_1_3_10_1_2_2_0 L0_N492 L1_N99 1.5663616684e+06
R_Conv_1_3_10_1_2_2_1 L0_N493 L1_N99 2.1466641264e+05
*
R_Conv_1_3_11_0_0_0_0 L0_N380 L1_N100 3.0927915375e+05
R_Conv_1_3_11_0_0_0_1 L0_N381 L1_N100 3.6154472179e+05
R_Conv_1_3_11_0_0_1_0 L0_N382 L1_N100 1.2307612303e+05
R_Conv_1_3_11_0_0_1_1 L0_N383 L1_N100 1.3361401953e+06
R_Conv_1_3_11_0_0_2_0 L0_N384 L1_N100 1.1771240850e+06
R_Conv_1_3_11_0_0_2_1 L0_N385 L1_N100 1.1947062568e+05
R_Conv_1_3_11_0_1_0_0 L0_N436 L1_N100 3.4555602430e+05
R_Conv_1_3_11_0_1_0_1 L0_N437 L1_N100 1.2140655673e+05
R_Conv_1_3_11_0_1_1_0 L0_N438 L1_N100 2.0024008865e+05
R_Conv_1_3_11_0_1_1_1 L0_N439 L1_N100 1.3019124074e+05
R_Conv_1_3_11_0_1_2_0 L0_N440 L1_N100 1.1085089352e+05
R_Conv_1_3_11_0_1_2_1 L0_N441 L1_N100 2.5251460583e+05
R_Conv_1_3_11_0_2_0_0 L0_N492 L1_N100 1.1040315248e+05
R_Conv_1_3_11_0_2_0_1 L0_N493 L1_N100 1.2105931856e+05
R_Conv_1_3_11_0_2_1_0 L0_N494 L1_N100 1.0186236681e+05
R_Conv_1_3_11_0_2_1_1 L0_N495 L1_N100 3.8798345399e+05
R_Conv_1_3_11_0_2_2_0 L0_N496 L1_N100 4.4022254443e+06
R_Conv_1_3_11_0_2_2_1 L0_N497 L1_N100 1.5358515901e+05
*
R_Conv_1_3_11_1_0_0_0 L0_N380 L1_N101 1.2123709737e+05
R_Conv_1_3_11_1_0_0_1 L0_N381 L1_N101 1.0849154640e+05
R_Conv_1_3_11_1_0_1_0 L0_N382 L1_N101 2.0480317885e+05
R_Conv_1_3_11_1_0_1_1 L0_N383 L1_N101 1.6641635952e+05
R_Conv_1_3_11_1_0_2_0 L0_N384 L1_N101 1.1683261279e+06
R_Conv_1_3_11_1_0_2_1 L0_N385 L1_N101 1.1602008983e+05
R_Conv_1_3_11_1_1_0_0 L0_N436 L1_N101 1.2296662853e+05
R_Conv_1_3_11_1_1_0_1 L0_N437 L1_N101 1.6882235068e+05
R_Conv_1_3_11_1_1_1_0 L0_N438 L1_N101 1.0472083211e+05
R_Conv_1_3_11_1_1_1_1 L0_N439 L1_N101 2.1167619859e+05
R_Conv_1_3_11_1_1_2_0 L0_N440 L1_N101 1.3518319025e+05
R_Conv_1_3_11_1_1_2_1 L0_N441 L1_N101 1.4280846670e+05
R_Conv_1_3_11_1_2_0_0 L0_N492 L1_N101 1.1620759255e+05
R_Conv_1_3_11_1_2_0_1 L0_N493 L1_N101 1.6895116802e+05
R_Conv_1_3_11_1_2_1_0 L0_N494 L1_N101 1.2455043512e+06
R_Conv_1_3_11_1_2_1_1 L0_N495 L1_N101 1.1694022847e+05
R_Conv_1_3_11_1_2_2_0 L0_N496 L1_N101 1.5663616684e+06
R_Conv_1_3_11_1_2_2_1 L0_N497 L1_N101 2.1466641264e+05
*
R_Conv_1_3_12_0_0_0_0 L0_N384 L1_N102 3.0927915375e+05
R_Conv_1_3_12_0_0_0_1 L0_N385 L1_N102 3.6154472179e+05
R_Conv_1_3_12_0_0_1_0 L0_N386 L1_N102 1.2307612303e+05
R_Conv_1_3_12_0_0_1_1 L0_N387 L1_N102 1.3361401953e+06
R_Conv_1_3_12_0_0_2_0 L0_N388 L1_N102 1.1771240850e+06
R_Conv_1_3_12_0_0_2_1 L0_N389 L1_N102 1.1947062568e+05
R_Conv_1_3_12_0_1_0_0 L0_N440 L1_N102 3.4555602430e+05
R_Conv_1_3_12_0_1_0_1 L0_N441 L1_N102 1.2140655673e+05
R_Conv_1_3_12_0_1_1_0 L0_N442 L1_N102 2.0024008865e+05
R_Conv_1_3_12_0_1_1_1 L0_N443 L1_N102 1.3019124074e+05
R_Conv_1_3_12_0_1_2_0 L0_N444 L1_N102 1.1085089352e+05
R_Conv_1_3_12_0_1_2_1 L0_N445 L1_N102 2.5251460583e+05
R_Conv_1_3_12_0_2_0_0 L0_N496 L1_N102 1.1040315248e+05
R_Conv_1_3_12_0_2_0_1 L0_N497 L1_N102 1.2105931856e+05
R_Conv_1_3_12_0_2_1_0 L0_N498 L1_N102 1.0186236681e+05
R_Conv_1_3_12_0_2_1_1 L0_N499 L1_N102 3.8798345399e+05
R_Conv_1_3_12_0_2_2_0 L0_N500 L1_N102 4.4022254443e+06
R_Conv_1_3_12_0_2_2_1 L0_N501 L1_N102 1.5358515901e+05
*
R_Conv_1_3_12_1_0_0_0 L0_N384 L1_N103 1.2123709737e+05
R_Conv_1_3_12_1_0_0_1 L0_N385 L1_N103 1.0849154640e+05
R_Conv_1_3_12_1_0_1_0 L0_N386 L1_N103 2.0480317885e+05
R_Conv_1_3_12_1_0_1_1 L0_N387 L1_N103 1.6641635952e+05
R_Conv_1_3_12_1_0_2_0 L0_N388 L1_N103 1.1683261279e+06
R_Conv_1_3_12_1_0_2_1 L0_N389 L1_N103 1.1602008983e+05
R_Conv_1_3_12_1_1_0_0 L0_N440 L1_N103 1.2296662853e+05
R_Conv_1_3_12_1_1_0_1 L0_N441 L1_N103 1.6882235068e+05
R_Conv_1_3_12_1_1_1_0 L0_N442 L1_N103 1.0472083211e+05
R_Conv_1_3_12_1_1_1_1 L0_N443 L1_N103 2.1167619859e+05
R_Conv_1_3_12_1_1_2_0 L0_N444 L1_N103 1.3518319025e+05
R_Conv_1_3_12_1_1_2_1 L0_N445 L1_N103 1.4280846670e+05
R_Conv_1_3_12_1_2_0_0 L0_N496 L1_N103 1.1620759255e+05
R_Conv_1_3_12_1_2_0_1 L0_N497 L1_N103 1.6895116802e+05
R_Conv_1_3_12_1_2_1_0 L0_N498 L1_N103 1.2455043512e+06
R_Conv_1_3_12_1_2_1_1 L0_N499 L1_N103 1.1694022847e+05
R_Conv_1_3_12_1_2_2_0 L0_N500 L1_N103 1.5663616684e+06
R_Conv_1_3_12_1_2_2_1 L0_N501 L1_N103 2.1466641264e+05
*
R_Conv_1_4_0_0_0_0_0 L0_N448 L1_N104 3.0927915375e+05
R_Conv_1_4_0_0_0_0_1 L0_N449 L1_N104 3.6154472179e+05
R_Conv_1_4_0_0_0_1_0 L0_N450 L1_N104 1.2307612303e+05
R_Conv_1_4_0_0_0_1_1 L0_N451 L1_N104 1.3361401953e+06
R_Conv_1_4_0_0_0_2_0 L0_N452 L1_N104 1.1771240850e+06
R_Conv_1_4_0_0_0_2_1 L0_N453 L1_N104 1.1947062568e+05
R_Conv_1_4_0_0_1_0_0 L0_N504 L1_N104 3.4555602430e+05
R_Conv_1_4_0_0_1_0_1 L0_N505 L1_N104 1.2140655673e+05
R_Conv_1_4_0_0_1_1_0 L0_N506 L1_N104 2.0024008865e+05
R_Conv_1_4_0_0_1_1_1 L0_N507 L1_N104 1.3019124074e+05
R_Conv_1_4_0_0_1_2_0 L0_N508 L1_N104 1.1085089352e+05
R_Conv_1_4_0_0_1_2_1 L0_N509 L1_N104 2.5251460583e+05
R_Conv_1_4_0_0_2_0_0 L0_N560 L1_N104 1.1040315248e+05
R_Conv_1_4_0_0_2_0_1 L0_N561 L1_N104 1.2105931856e+05
R_Conv_1_4_0_0_2_1_0 L0_N562 L1_N104 1.0186236681e+05
R_Conv_1_4_0_0_2_1_1 L0_N563 L1_N104 3.8798345399e+05
R_Conv_1_4_0_0_2_2_0 L0_N564 L1_N104 4.4022254443e+06
R_Conv_1_4_0_0_2_2_1 L0_N565 L1_N104 1.5358515901e+05
*
R_Conv_1_4_0_1_0_0_0 L0_N448 L1_N105 1.2123709737e+05
R_Conv_1_4_0_1_0_0_1 L0_N449 L1_N105 1.0849154640e+05
R_Conv_1_4_0_1_0_1_0 L0_N450 L1_N105 2.0480317885e+05
R_Conv_1_4_0_1_0_1_1 L0_N451 L1_N105 1.6641635952e+05
R_Conv_1_4_0_1_0_2_0 L0_N452 L1_N105 1.1683261279e+06
R_Conv_1_4_0_1_0_2_1 L0_N453 L1_N105 1.1602008983e+05
R_Conv_1_4_0_1_1_0_0 L0_N504 L1_N105 1.2296662853e+05
R_Conv_1_4_0_1_1_0_1 L0_N505 L1_N105 1.6882235068e+05
R_Conv_1_4_0_1_1_1_0 L0_N506 L1_N105 1.0472083211e+05
R_Conv_1_4_0_1_1_1_1 L0_N507 L1_N105 2.1167619859e+05
R_Conv_1_4_0_1_1_2_0 L0_N508 L1_N105 1.3518319025e+05
R_Conv_1_4_0_1_1_2_1 L0_N509 L1_N105 1.4280846670e+05
R_Conv_1_4_0_1_2_0_0 L0_N560 L1_N105 1.1620759255e+05
R_Conv_1_4_0_1_2_0_1 L0_N561 L1_N105 1.6895116802e+05
R_Conv_1_4_0_1_2_1_0 L0_N562 L1_N105 1.2455043512e+06
R_Conv_1_4_0_1_2_1_1 L0_N563 L1_N105 1.1694022847e+05
R_Conv_1_4_0_1_2_2_0 L0_N564 L1_N105 1.5663616684e+06
R_Conv_1_4_0_1_2_2_1 L0_N565 L1_N105 2.1466641264e+05
*
R_Conv_1_4_1_0_0_0_0 L0_N452 L1_N106 3.0927915375e+05
R_Conv_1_4_1_0_0_0_1 L0_N453 L1_N106 3.6154472179e+05
R_Conv_1_4_1_0_0_1_0 L0_N454 L1_N106 1.2307612303e+05
R_Conv_1_4_1_0_0_1_1 L0_N455 L1_N106 1.3361401953e+06
R_Conv_1_4_1_0_0_2_0 L0_N456 L1_N106 1.1771240850e+06
R_Conv_1_4_1_0_0_2_1 L0_N457 L1_N106 1.1947062568e+05
R_Conv_1_4_1_0_1_0_0 L0_N508 L1_N106 3.4555602430e+05
R_Conv_1_4_1_0_1_0_1 L0_N509 L1_N106 1.2140655673e+05
R_Conv_1_4_1_0_1_1_0 L0_N510 L1_N106 2.0024008865e+05
R_Conv_1_4_1_0_1_1_1 L0_N511 L1_N106 1.3019124074e+05
R_Conv_1_4_1_0_1_2_0 L0_N512 L1_N106 1.1085089352e+05
R_Conv_1_4_1_0_1_2_1 L0_N513 L1_N106 2.5251460583e+05
R_Conv_1_4_1_0_2_0_0 L0_N564 L1_N106 1.1040315248e+05
R_Conv_1_4_1_0_2_0_1 L0_N565 L1_N106 1.2105931856e+05
R_Conv_1_4_1_0_2_1_0 L0_N566 L1_N106 1.0186236681e+05
R_Conv_1_4_1_0_2_1_1 L0_N567 L1_N106 3.8798345399e+05
R_Conv_1_4_1_0_2_2_0 L0_N568 L1_N106 4.4022254443e+06
R_Conv_1_4_1_0_2_2_1 L0_N569 L1_N106 1.5358515901e+05
*
R_Conv_1_4_1_1_0_0_0 L0_N452 L1_N107 1.2123709737e+05
R_Conv_1_4_1_1_0_0_1 L0_N453 L1_N107 1.0849154640e+05
R_Conv_1_4_1_1_0_1_0 L0_N454 L1_N107 2.0480317885e+05
R_Conv_1_4_1_1_0_1_1 L0_N455 L1_N107 1.6641635952e+05
R_Conv_1_4_1_1_0_2_0 L0_N456 L1_N107 1.1683261279e+06
R_Conv_1_4_1_1_0_2_1 L0_N457 L1_N107 1.1602008983e+05
R_Conv_1_4_1_1_1_0_0 L0_N508 L1_N107 1.2296662853e+05
R_Conv_1_4_1_1_1_0_1 L0_N509 L1_N107 1.6882235068e+05
R_Conv_1_4_1_1_1_1_0 L0_N510 L1_N107 1.0472083211e+05
R_Conv_1_4_1_1_1_1_1 L0_N511 L1_N107 2.1167619859e+05
R_Conv_1_4_1_1_1_2_0 L0_N512 L1_N107 1.3518319025e+05
R_Conv_1_4_1_1_1_2_1 L0_N513 L1_N107 1.4280846670e+05
R_Conv_1_4_1_1_2_0_0 L0_N564 L1_N107 1.1620759255e+05
R_Conv_1_4_1_1_2_0_1 L0_N565 L1_N107 1.6895116802e+05
R_Conv_1_4_1_1_2_1_0 L0_N566 L1_N107 1.2455043512e+06
R_Conv_1_4_1_1_2_1_1 L0_N567 L1_N107 1.1694022847e+05
R_Conv_1_4_1_1_2_2_0 L0_N568 L1_N107 1.5663616684e+06
R_Conv_1_4_1_1_2_2_1 L0_N569 L1_N107 2.1466641264e+05
*
R_Conv_1_4_2_0_0_0_0 L0_N456 L1_N108 3.0927915375e+05
R_Conv_1_4_2_0_0_0_1 L0_N457 L1_N108 3.6154472179e+05
R_Conv_1_4_2_0_0_1_0 L0_N458 L1_N108 1.2307612303e+05
R_Conv_1_4_2_0_0_1_1 L0_N459 L1_N108 1.3361401953e+06
R_Conv_1_4_2_0_0_2_0 L0_N460 L1_N108 1.1771240850e+06
R_Conv_1_4_2_0_0_2_1 L0_N461 L1_N108 1.1947062568e+05
R_Conv_1_4_2_0_1_0_0 L0_N512 L1_N108 3.4555602430e+05
R_Conv_1_4_2_0_1_0_1 L0_N513 L1_N108 1.2140655673e+05
R_Conv_1_4_2_0_1_1_0 L0_N514 L1_N108 2.0024008865e+05
R_Conv_1_4_2_0_1_1_1 L0_N515 L1_N108 1.3019124074e+05
R_Conv_1_4_2_0_1_2_0 L0_N516 L1_N108 1.1085089352e+05
R_Conv_1_4_2_0_1_2_1 L0_N517 L1_N108 2.5251460583e+05
R_Conv_1_4_2_0_2_0_0 L0_N568 L1_N108 1.1040315248e+05
R_Conv_1_4_2_0_2_0_1 L0_N569 L1_N108 1.2105931856e+05
R_Conv_1_4_2_0_2_1_0 L0_N570 L1_N108 1.0186236681e+05
R_Conv_1_4_2_0_2_1_1 L0_N571 L1_N108 3.8798345399e+05
R_Conv_1_4_2_0_2_2_0 L0_N572 L1_N108 4.4022254443e+06
R_Conv_1_4_2_0_2_2_1 L0_N573 L1_N108 1.5358515901e+05
*
R_Conv_1_4_2_1_0_0_0 L0_N456 L1_N109 1.2123709737e+05
R_Conv_1_4_2_1_0_0_1 L0_N457 L1_N109 1.0849154640e+05
R_Conv_1_4_2_1_0_1_0 L0_N458 L1_N109 2.0480317885e+05
R_Conv_1_4_2_1_0_1_1 L0_N459 L1_N109 1.6641635952e+05
R_Conv_1_4_2_1_0_2_0 L0_N460 L1_N109 1.1683261279e+06
R_Conv_1_4_2_1_0_2_1 L0_N461 L1_N109 1.1602008983e+05
R_Conv_1_4_2_1_1_0_0 L0_N512 L1_N109 1.2296662853e+05
R_Conv_1_4_2_1_1_0_1 L0_N513 L1_N109 1.6882235068e+05
R_Conv_1_4_2_1_1_1_0 L0_N514 L1_N109 1.0472083211e+05
R_Conv_1_4_2_1_1_1_1 L0_N515 L1_N109 2.1167619859e+05
R_Conv_1_4_2_1_1_2_0 L0_N516 L1_N109 1.3518319025e+05
R_Conv_1_4_2_1_1_2_1 L0_N517 L1_N109 1.4280846670e+05
R_Conv_1_4_2_1_2_0_0 L0_N568 L1_N109 1.1620759255e+05
R_Conv_1_4_2_1_2_0_1 L0_N569 L1_N109 1.6895116802e+05
R_Conv_1_4_2_1_2_1_0 L0_N570 L1_N109 1.2455043512e+06
R_Conv_1_4_2_1_2_1_1 L0_N571 L1_N109 1.1694022847e+05
R_Conv_1_4_2_1_2_2_0 L0_N572 L1_N109 1.5663616684e+06
R_Conv_1_4_2_1_2_2_1 L0_N573 L1_N109 2.1466641264e+05
*
R_Conv_1_4_3_0_0_0_0 L0_N460 L1_N110 3.0927915375e+05
R_Conv_1_4_3_0_0_0_1 L0_N461 L1_N110 3.6154472179e+05
R_Conv_1_4_3_0_0_1_0 L0_N462 L1_N110 1.2307612303e+05
R_Conv_1_4_3_0_0_1_1 L0_N463 L1_N110 1.3361401953e+06
R_Conv_1_4_3_0_0_2_0 L0_N464 L1_N110 1.1771240850e+06
R_Conv_1_4_3_0_0_2_1 L0_N465 L1_N110 1.1947062568e+05
R_Conv_1_4_3_0_1_0_0 L0_N516 L1_N110 3.4555602430e+05
R_Conv_1_4_3_0_1_0_1 L0_N517 L1_N110 1.2140655673e+05
R_Conv_1_4_3_0_1_1_0 L0_N518 L1_N110 2.0024008865e+05
R_Conv_1_4_3_0_1_1_1 L0_N519 L1_N110 1.3019124074e+05
R_Conv_1_4_3_0_1_2_0 L0_N520 L1_N110 1.1085089352e+05
R_Conv_1_4_3_0_1_2_1 L0_N521 L1_N110 2.5251460583e+05
R_Conv_1_4_3_0_2_0_0 L0_N572 L1_N110 1.1040315248e+05
R_Conv_1_4_3_0_2_0_1 L0_N573 L1_N110 1.2105931856e+05
R_Conv_1_4_3_0_2_1_0 L0_N574 L1_N110 1.0186236681e+05
R_Conv_1_4_3_0_2_1_1 L0_N575 L1_N110 3.8798345399e+05
R_Conv_1_4_3_0_2_2_0 L0_N576 L1_N110 4.4022254443e+06
R_Conv_1_4_3_0_2_2_1 L0_N577 L1_N110 1.5358515901e+05
*
R_Conv_1_4_3_1_0_0_0 L0_N460 L1_N111 1.2123709737e+05
R_Conv_1_4_3_1_0_0_1 L0_N461 L1_N111 1.0849154640e+05
R_Conv_1_4_3_1_0_1_0 L0_N462 L1_N111 2.0480317885e+05
R_Conv_1_4_3_1_0_1_1 L0_N463 L1_N111 1.6641635952e+05
R_Conv_1_4_3_1_0_2_0 L0_N464 L1_N111 1.1683261279e+06
R_Conv_1_4_3_1_0_2_1 L0_N465 L1_N111 1.1602008983e+05
R_Conv_1_4_3_1_1_0_0 L0_N516 L1_N111 1.2296662853e+05
R_Conv_1_4_3_1_1_0_1 L0_N517 L1_N111 1.6882235068e+05
R_Conv_1_4_3_1_1_1_0 L0_N518 L1_N111 1.0472083211e+05
R_Conv_1_4_3_1_1_1_1 L0_N519 L1_N111 2.1167619859e+05
R_Conv_1_4_3_1_1_2_0 L0_N520 L1_N111 1.3518319025e+05
R_Conv_1_4_3_1_1_2_1 L0_N521 L1_N111 1.4280846670e+05
R_Conv_1_4_3_1_2_0_0 L0_N572 L1_N111 1.1620759255e+05
R_Conv_1_4_3_1_2_0_1 L0_N573 L1_N111 1.6895116802e+05
R_Conv_1_4_3_1_2_1_0 L0_N574 L1_N111 1.2455043512e+06
R_Conv_1_4_3_1_2_1_1 L0_N575 L1_N111 1.1694022847e+05
R_Conv_1_4_3_1_2_2_0 L0_N576 L1_N111 1.5663616684e+06
R_Conv_1_4_3_1_2_2_1 L0_N577 L1_N111 2.1466641264e+05
*
R_Conv_1_4_4_0_0_0_0 L0_N464 L1_N112 3.0927915375e+05
R_Conv_1_4_4_0_0_0_1 L0_N465 L1_N112 3.6154472179e+05
R_Conv_1_4_4_0_0_1_0 L0_N466 L1_N112 1.2307612303e+05
R_Conv_1_4_4_0_0_1_1 L0_N467 L1_N112 1.3361401953e+06
R_Conv_1_4_4_0_0_2_0 L0_N468 L1_N112 1.1771240850e+06
R_Conv_1_4_4_0_0_2_1 L0_N469 L1_N112 1.1947062568e+05
R_Conv_1_4_4_0_1_0_0 L0_N520 L1_N112 3.4555602430e+05
R_Conv_1_4_4_0_1_0_1 L0_N521 L1_N112 1.2140655673e+05
R_Conv_1_4_4_0_1_1_0 L0_N522 L1_N112 2.0024008865e+05
R_Conv_1_4_4_0_1_1_1 L0_N523 L1_N112 1.3019124074e+05
R_Conv_1_4_4_0_1_2_0 L0_N524 L1_N112 1.1085089352e+05
R_Conv_1_4_4_0_1_2_1 L0_N525 L1_N112 2.5251460583e+05
R_Conv_1_4_4_0_2_0_0 L0_N576 L1_N112 1.1040315248e+05
R_Conv_1_4_4_0_2_0_1 L0_N577 L1_N112 1.2105931856e+05
R_Conv_1_4_4_0_2_1_0 L0_N578 L1_N112 1.0186236681e+05
R_Conv_1_4_4_0_2_1_1 L0_N579 L1_N112 3.8798345399e+05
R_Conv_1_4_4_0_2_2_0 L0_N580 L1_N112 4.4022254443e+06
R_Conv_1_4_4_0_2_2_1 L0_N581 L1_N112 1.5358515901e+05
*
R_Conv_1_4_4_1_0_0_0 L0_N464 L1_N113 1.2123709737e+05
R_Conv_1_4_4_1_0_0_1 L0_N465 L1_N113 1.0849154640e+05
R_Conv_1_4_4_1_0_1_0 L0_N466 L1_N113 2.0480317885e+05
R_Conv_1_4_4_1_0_1_1 L0_N467 L1_N113 1.6641635952e+05
R_Conv_1_4_4_1_0_2_0 L0_N468 L1_N113 1.1683261279e+06
R_Conv_1_4_4_1_0_2_1 L0_N469 L1_N113 1.1602008983e+05
R_Conv_1_4_4_1_1_0_0 L0_N520 L1_N113 1.2296662853e+05
R_Conv_1_4_4_1_1_0_1 L0_N521 L1_N113 1.6882235068e+05
R_Conv_1_4_4_1_1_1_0 L0_N522 L1_N113 1.0472083211e+05
R_Conv_1_4_4_1_1_1_1 L0_N523 L1_N113 2.1167619859e+05
R_Conv_1_4_4_1_1_2_0 L0_N524 L1_N113 1.3518319025e+05
R_Conv_1_4_4_1_1_2_1 L0_N525 L1_N113 1.4280846670e+05
R_Conv_1_4_4_1_2_0_0 L0_N576 L1_N113 1.1620759255e+05
R_Conv_1_4_4_1_2_0_1 L0_N577 L1_N113 1.6895116802e+05
R_Conv_1_4_4_1_2_1_0 L0_N578 L1_N113 1.2455043512e+06
R_Conv_1_4_4_1_2_1_1 L0_N579 L1_N113 1.1694022847e+05
R_Conv_1_4_4_1_2_2_0 L0_N580 L1_N113 1.5663616684e+06
R_Conv_1_4_4_1_2_2_1 L0_N581 L1_N113 2.1466641264e+05
*
R_Conv_1_4_5_0_0_0_0 L0_N468 L1_N114 3.0927915375e+05
R_Conv_1_4_5_0_0_0_1 L0_N469 L1_N114 3.6154472179e+05
R_Conv_1_4_5_0_0_1_0 L0_N470 L1_N114 1.2307612303e+05
R_Conv_1_4_5_0_0_1_1 L0_N471 L1_N114 1.3361401953e+06
R_Conv_1_4_5_0_0_2_0 L0_N472 L1_N114 1.1771240850e+06
R_Conv_1_4_5_0_0_2_1 L0_N473 L1_N114 1.1947062568e+05
R_Conv_1_4_5_0_1_0_0 L0_N524 L1_N114 3.4555602430e+05
R_Conv_1_4_5_0_1_0_1 L0_N525 L1_N114 1.2140655673e+05
R_Conv_1_4_5_0_1_1_0 L0_N526 L1_N114 2.0024008865e+05
R_Conv_1_4_5_0_1_1_1 L0_N527 L1_N114 1.3019124074e+05
R_Conv_1_4_5_0_1_2_0 L0_N528 L1_N114 1.1085089352e+05
R_Conv_1_4_5_0_1_2_1 L0_N529 L1_N114 2.5251460583e+05
R_Conv_1_4_5_0_2_0_0 L0_N580 L1_N114 1.1040315248e+05
R_Conv_1_4_5_0_2_0_1 L0_N581 L1_N114 1.2105931856e+05
R_Conv_1_4_5_0_2_1_0 L0_N582 L1_N114 1.0186236681e+05
R_Conv_1_4_5_0_2_1_1 L0_N583 L1_N114 3.8798345399e+05
R_Conv_1_4_5_0_2_2_0 L0_N584 L1_N114 4.4022254443e+06
R_Conv_1_4_5_0_2_2_1 L0_N585 L1_N114 1.5358515901e+05
*
R_Conv_1_4_5_1_0_0_0 L0_N468 L1_N115 1.2123709737e+05
R_Conv_1_4_5_1_0_0_1 L0_N469 L1_N115 1.0849154640e+05
R_Conv_1_4_5_1_0_1_0 L0_N470 L1_N115 2.0480317885e+05
R_Conv_1_4_5_1_0_1_1 L0_N471 L1_N115 1.6641635952e+05
R_Conv_1_4_5_1_0_2_0 L0_N472 L1_N115 1.1683261279e+06
R_Conv_1_4_5_1_0_2_1 L0_N473 L1_N115 1.1602008983e+05
R_Conv_1_4_5_1_1_0_0 L0_N524 L1_N115 1.2296662853e+05
R_Conv_1_4_5_1_1_0_1 L0_N525 L1_N115 1.6882235068e+05
R_Conv_1_4_5_1_1_1_0 L0_N526 L1_N115 1.0472083211e+05
R_Conv_1_4_5_1_1_1_1 L0_N527 L1_N115 2.1167619859e+05
R_Conv_1_4_5_1_1_2_0 L0_N528 L1_N115 1.3518319025e+05
R_Conv_1_4_5_1_1_2_1 L0_N529 L1_N115 1.4280846670e+05
R_Conv_1_4_5_1_2_0_0 L0_N580 L1_N115 1.1620759255e+05
R_Conv_1_4_5_1_2_0_1 L0_N581 L1_N115 1.6895116802e+05
R_Conv_1_4_5_1_2_1_0 L0_N582 L1_N115 1.2455043512e+06
R_Conv_1_4_5_1_2_1_1 L0_N583 L1_N115 1.1694022847e+05
R_Conv_1_4_5_1_2_2_0 L0_N584 L1_N115 1.5663616684e+06
R_Conv_1_4_5_1_2_2_1 L0_N585 L1_N115 2.1466641264e+05
*
R_Conv_1_4_6_0_0_0_0 L0_N472 L1_N116 3.0927915375e+05
R_Conv_1_4_6_0_0_0_1 L0_N473 L1_N116 3.6154472179e+05
R_Conv_1_4_6_0_0_1_0 L0_N474 L1_N116 1.2307612303e+05
R_Conv_1_4_6_0_0_1_1 L0_N475 L1_N116 1.3361401953e+06
R_Conv_1_4_6_0_0_2_0 L0_N476 L1_N116 1.1771240850e+06
R_Conv_1_4_6_0_0_2_1 L0_N477 L1_N116 1.1947062568e+05
R_Conv_1_4_6_0_1_0_0 L0_N528 L1_N116 3.4555602430e+05
R_Conv_1_4_6_0_1_0_1 L0_N529 L1_N116 1.2140655673e+05
R_Conv_1_4_6_0_1_1_0 L0_N530 L1_N116 2.0024008865e+05
R_Conv_1_4_6_0_1_1_1 L0_N531 L1_N116 1.3019124074e+05
R_Conv_1_4_6_0_1_2_0 L0_N532 L1_N116 1.1085089352e+05
R_Conv_1_4_6_0_1_2_1 L0_N533 L1_N116 2.5251460583e+05
R_Conv_1_4_6_0_2_0_0 L0_N584 L1_N116 1.1040315248e+05
R_Conv_1_4_6_0_2_0_1 L0_N585 L1_N116 1.2105931856e+05
R_Conv_1_4_6_0_2_1_0 L0_N586 L1_N116 1.0186236681e+05
R_Conv_1_4_6_0_2_1_1 L0_N587 L1_N116 3.8798345399e+05
R_Conv_1_4_6_0_2_2_0 L0_N588 L1_N116 4.4022254443e+06
R_Conv_1_4_6_0_2_2_1 L0_N589 L1_N116 1.5358515901e+05
*
R_Conv_1_4_6_1_0_0_0 L0_N472 L1_N117 1.2123709737e+05
R_Conv_1_4_6_1_0_0_1 L0_N473 L1_N117 1.0849154640e+05
R_Conv_1_4_6_1_0_1_0 L0_N474 L1_N117 2.0480317885e+05
R_Conv_1_4_6_1_0_1_1 L0_N475 L1_N117 1.6641635952e+05
R_Conv_1_4_6_1_0_2_0 L0_N476 L1_N117 1.1683261279e+06
R_Conv_1_4_6_1_0_2_1 L0_N477 L1_N117 1.1602008983e+05
R_Conv_1_4_6_1_1_0_0 L0_N528 L1_N117 1.2296662853e+05
R_Conv_1_4_6_1_1_0_1 L0_N529 L1_N117 1.6882235068e+05
R_Conv_1_4_6_1_1_1_0 L0_N530 L1_N117 1.0472083211e+05
R_Conv_1_4_6_1_1_1_1 L0_N531 L1_N117 2.1167619859e+05
R_Conv_1_4_6_1_1_2_0 L0_N532 L1_N117 1.3518319025e+05
R_Conv_1_4_6_1_1_2_1 L0_N533 L1_N117 1.4280846670e+05
R_Conv_1_4_6_1_2_0_0 L0_N584 L1_N117 1.1620759255e+05
R_Conv_1_4_6_1_2_0_1 L0_N585 L1_N117 1.6895116802e+05
R_Conv_1_4_6_1_2_1_0 L0_N586 L1_N117 1.2455043512e+06
R_Conv_1_4_6_1_2_1_1 L0_N587 L1_N117 1.1694022847e+05
R_Conv_1_4_6_1_2_2_0 L0_N588 L1_N117 1.5663616684e+06
R_Conv_1_4_6_1_2_2_1 L0_N589 L1_N117 2.1466641264e+05
*
R_Conv_1_4_7_0_0_0_0 L0_N476 L1_N118 3.0927915375e+05
R_Conv_1_4_7_0_0_0_1 L0_N477 L1_N118 3.6154472179e+05
R_Conv_1_4_7_0_0_1_0 L0_N478 L1_N118 1.2307612303e+05
R_Conv_1_4_7_0_0_1_1 L0_N479 L1_N118 1.3361401953e+06
R_Conv_1_4_7_0_0_2_0 L0_N480 L1_N118 1.1771240850e+06
R_Conv_1_4_7_0_0_2_1 L0_N481 L1_N118 1.1947062568e+05
R_Conv_1_4_7_0_1_0_0 L0_N532 L1_N118 3.4555602430e+05
R_Conv_1_4_7_0_1_0_1 L0_N533 L1_N118 1.2140655673e+05
R_Conv_1_4_7_0_1_1_0 L0_N534 L1_N118 2.0024008865e+05
R_Conv_1_4_7_0_1_1_1 L0_N535 L1_N118 1.3019124074e+05
R_Conv_1_4_7_0_1_2_0 L0_N536 L1_N118 1.1085089352e+05
R_Conv_1_4_7_0_1_2_1 L0_N537 L1_N118 2.5251460583e+05
R_Conv_1_4_7_0_2_0_0 L0_N588 L1_N118 1.1040315248e+05
R_Conv_1_4_7_0_2_0_1 L0_N589 L1_N118 1.2105931856e+05
R_Conv_1_4_7_0_2_1_0 L0_N590 L1_N118 1.0186236681e+05
R_Conv_1_4_7_0_2_1_1 L0_N591 L1_N118 3.8798345399e+05
R_Conv_1_4_7_0_2_2_0 L0_N592 L1_N118 4.4022254443e+06
R_Conv_1_4_7_0_2_2_1 L0_N593 L1_N118 1.5358515901e+05
*
R_Conv_1_4_7_1_0_0_0 L0_N476 L1_N119 1.2123709737e+05
R_Conv_1_4_7_1_0_0_1 L0_N477 L1_N119 1.0849154640e+05
R_Conv_1_4_7_1_0_1_0 L0_N478 L1_N119 2.0480317885e+05
R_Conv_1_4_7_1_0_1_1 L0_N479 L1_N119 1.6641635952e+05
R_Conv_1_4_7_1_0_2_0 L0_N480 L1_N119 1.1683261279e+06
R_Conv_1_4_7_1_0_2_1 L0_N481 L1_N119 1.1602008983e+05
R_Conv_1_4_7_1_1_0_0 L0_N532 L1_N119 1.2296662853e+05
R_Conv_1_4_7_1_1_0_1 L0_N533 L1_N119 1.6882235068e+05
R_Conv_1_4_7_1_1_1_0 L0_N534 L1_N119 1.0472083211e+05
R_Conv_1_4_7_1_1_1_1 L0_N535 L1_N119 2.1167619859e+05
R_Conv_1_4_7_1_1_2_0 L0_N536 L1_N119 1.3518319025e+05
R_Conv_1_4_7_1_1_2_1 L0_N537 L1_N119 1.4280846670e+05
R_Conv_1_4_7_1_2_0_0 L0_N588 L1_N119 1.1620759255e+05
R_Conv_1_4_7_1_2_0_1 L0_N589 L1_N119 1.6895116802e+05
R_Conv_1_4_7_1_2_1_0 L0_N590 L1_N119 1.2455043512e+06
R_Conv_1_4_7_1_2_1_1 L0_N591 L1_N119 1.1694022847e+05
R_Conv_1_4_7_1_2_2_0 L0_N592 L1_N119 1.5663616684e+06
R_Conv_1_4_7_1_2_2_1 L0_N593 L1_N119 2.1466641264e+05
*
R_Conv_1_4_8_0_0_0_0 L0_N480 L1_N120 3.0927915375e+05
R_Conv_1_4_8_0_0_0_1 L0_N481 L1_N120 3.6154472179e+05
R_Conv_1_4_8_0_0_1_0 L0_N482 L1_N120 1.2307612303e+05
R_Conv_1_4_8_0_0_1_1 L0_N483 L1_N120 1.3361401953e+06
R_Conv_1_4_8_0_0_2_0 L0_N484 L1_N120 1.1771240850e+06
R_Conv_1_4_8_0_0_2_1 L0_N485 L1_N120 1.1947062568e+05
R_Conv_1_4_8_0_1_0_0 L0_N536 L1_N120 3.4555602430e+05
R_Conv_1_4_8_0_1_0_1 L0_N537 L1_N120 1.2140655673e+05
R_Conv_1_4_8_0_1_1_0 L0_N538 L1_N120 2.0024008865e+05
R_Conv_1_4_8_0_1_1_1 L0_N539 L1_N120 1.3019124074e+05
R_Conv_1_4_8_0_1_2_0 L0_N540 L1_N120 1.1085089352e+05
R_Conv_1_4_8_0_1_2_1 L0_N541 L1_N120 2.5251460583e+05
R_Conv_1_4_8_0_2_0_0 L0_N592 L1_N120 1.1040315248e+05
R_Conv_1_4_8_0_2_0_1 L0_N593 L1_N120 1.2105931856e+05
R_Conv_1_4_8_0_2_1_0 L0_N594 L1_N120 1.0186236681e+05
R_Conv_1_4_8_0_2_1_1 L0_N595 L1_N120 3.8798345399e+05
R_Conv_1_4_8_0_2_2_0 L0_N596 L1_N120 4.4022254443e+06
R_Conv_1_4_8_0_2_2_1 L0_N597 L1_N120 1.5358515901e+05
*
R_Conv_1_4_8_1_0_0_0 L0_N480 L1_N121 1.2123709737e+05
R_Conv_1_4_8_1_0_0_1 L0_N481 L1_N121 1.0849154640e+05
R_Conv_1_4_8_1_0_1_0 L0_N482 L1_N121 2.0480317885e+05
R_Conv_1_4_8_1_0_1_1 L0_N483 L1_N121 1.6641635952e+05
R_Conv_1_4_8_1_0_2_0 L0_N484 L1_N121 1.1683261279e+06
R_Conv_1_4_8_1_0_2_1 L0_N485 L1_N121 1.1602008983e+05
R_Conv_1_4_8_1_1_0_0 L0_N536 L1_N121 1.2296662853e+05
R_Conv_1_4_8_1_1_0_1 L0_N537 L1_N121 1.6882235068e+05
R_Conv_1_4_8_1_1_1_0 L0_N538 L1_N121 1.0472083211e+05
R_Conv_1_4_8_1_1_1_1 L0_N539 L1_N121 2.1167619859e+05
R_Conv_1_4_8_1_1_2_0 L0_N540 L1_N121 1.3518319025e+05
R_Conv_1_4_8_1_1_2_1 L0_N541 L1_N121 1.4280846670e+05
R_Conv_1_4_8_1_2_0_0 L0_N592 L1_N121 1.1620759255e+05
R_Conv_1_4_8_1_2_0_1 L0_N593 L1_N121 1.6895116802e+05
R_Conv_1_4_8_1_2_1_0 L0_N594 L1_N121 1.2455043512e+06
R_Conv_1_4_8_1_2_1_1 L0_N595 L1_N121 1.1694022847e+05
R_Conv_1_4_8_1_2_2_0 L0_N596 L1_N121 1.5663616684e+06
R_Conv_1_4_8_1_2_2_1 L0_N597 L1_N121 2.1466641264e+05
*
R_Conv_1_4_9_0_0_0_0 L0_N484 L1_N122 3.0927915375e+05
R_Conv_1_4_9_0_0_0_1 L0_N485 L1_N122 3.6154472179e+05
R_Conv_1_4_9_0_0_1_0 L0_N486 L1_N122 1.2307612303e+05
R_Conv_1_4_9_0_0_1_1 L0_N487 L1_N122 1.3361401953e+06
R_Conv_1_4_9_0_0_2_0 L0_N488 L1_N122 1.1771240850e+06
R_Conv_1_4_9_0_0_2_1 L0_N489 L1_N122 1.1947062568e+05
R_Conv_1_4_9_0_1_0_0 L0_N540 L1_N122 3.4555602430e+05
R_Conv_1_4_9_0_1_0_1 L0_N541 L1_N122 1.2140655673e+05
R_Conv_1_4_9_0_1_1_0 L0_N542 L1_N122 2.0024008865e+05
R_Conv_1_4_9_0_1_1_1 L0_N543 L1_N122 1.3019124074e+05
R_Conv_1_4_9_0_1_2_0 L0_N544 L1_N122 1.1085089352e+05
R_Conv_1_4_9_0_1_2_1 L0_N545 L1_N122 2.5251460583e+05
R_Conv_1_4_9_0_2_0_0 L0_N596 L1_N122 1.1040315248e+05
R_Conv_1_4_9_0_2_0_1 L0_N597 L1_N122 1.2105931856e+05
R_Conv_1_4_9_0_2_1_0 L0_N598 L1_N122 1.0186236681e+05
R_Conv_1_4_9_0_2_1_1 L0_N599 L1_N122 3.8798345399e+05
R_Conv_1_4_9_0_2_2_0 L0_N600 L1_N122 4.4022254443e+06
R_Conv_1_4_9_0_2_2_1 L0_N601 L1_N122 1.5358515901e+05
*
R_Conv_1_4_9_1_0_0_0 L0_N484 L1_N123 1.2123709737e+05
R_Conv_1_4_9_1_0_0_1 L0_N485 L1_N123 1.0849154640e+05
R_Conv_1_4_9_1_0_1_0 L0_N486 L1_N123 2.0480317885e+05
R_Conv_1_4_9_1_0_1_1 L0_N487 L1_N123 1.6641635952e+05
R_Conv_1_4_9_1_0_2_0 L0_N488 L1_N123 1.1683261279e+06
R_Conv_1_4_9_1_0_2_1 L0_N489 L1_N123 1.1602008983e+05
R_Conv_1_4_9_1_1_0_0 L0_N540 L1_N123 1.2296662853e+05
R_Conv_1_4_9_1_1_0_1 L0_N541 L1_N123 1.6882235068e+05
R_Conv_1_4_9_1_1_1_0 L0_N542 L1_N123 1.0472083211e+05
R_Conv_1_4_9_1_1_1_1 L0_N543 L1_N123 2.1167619859e+05
R_Conv_1_4_9_1_1_2_0 L0_N544 L1_N123 1.3518319025e+05
R_Conv_1_4_9_1_1_2_1 L0_N545 L1_N123 1.4280846670e+05
R_Conv_1_4_9_1_2_0_0 L0_N596 L1_N123 1.1620759255e+05
R_Conv_1_4_9_1_2_0_1 L0_N597 L1_N123 1.6895116802e+05
R_Conv_1_4_9_1_2_1_0 L0_N598 L1_N123 1.2455043512e+06
R_Conv_1_4_9_1_2_1_1 L0_N599 L1_N123 1.1694022847e+05
R_Conv_1_4_9_1_2_2_0 L0_N600 L1_N123 1.5663616684e+06
R_Conv_1_4_9_1_2_2_1 L0_N601 L1_N123 2.1466641264e+05
*
R_Conv_1_4_10_0_0_0_0 L0_N488 L1_N124 3.0927915375e+05
R_Conv_1_4_10_0_0_0_1 L0_N489 L1_N124 3.6154472179e+05
R_Conv_1_4_10_0_0_1_0 L0_N490 L1_N124 1.2307612303e+05
R_Conv_1_4_10_0_0_1_1 L0_N491 L1_N124 1.3361401953e+06
R_Conv_1_4_10_0_0_2_0 L0_N492 L1_N124 1.1771240850e+06
R_Conv_1_4_10_0_0_2_1 L0_N493 L1_N124 1.1947062568e+05
R_Conv_1_4_10_0_1_0_0 L0_N544 L1_N124 3.4555602430e+05
R_Conv_1_4_10_0_1_0_1 L0_N545 L1_N124 1.2140655673e+05
R_Conv_1_4_10_0_1_1_0 L0_N546 L1_N124 2.0024008865e+05
R_Conv_1_4_10_0_1_1_1 L0_N547 L1_N124 1.3019124074e+05
R_Conv_1_4_10_0_1_2_0 L0_N548 L1_N124 1.1085089352e+05
R_Conv_1_4_10_0_1_2_1 L0_N549 L1_N124 2.5251460583e+05
R_Conv_1_4_10_0_2_0_0 L0_N600 L1_N124 1.1040315248e+05
R_Conv_1_4_10_0_2_0_1 L0_N601 L1_N124 1.2105931856e+05
R_Conv_1_4_10_0_2_1_0 L0_N602 L1_N124 1.0186236681e+05
R_Conv_1_4_10_0_2_1_1 L0_N603 L1_N124 3.8798345399e+05
R_Conv_1_4_10_0_2_2_0 L0_N604 L1_N124 4.4022254443e+06
R_Conv_1_4_10_0_2_2_1 L0_N605 L1_N124 1.5358515901e+05
*
R_Conv_1_4_10_1_0_0_0 L0_N488 L1_N125 1.2123709737e+05
R_Conv_1_4_10_1_0_0_1 L0_N489 L1_N125 1.0849154640e+05
R_Conv_1_4_10_1_0_1_0 L0_N490 L1_N125 2.0480317885e+05
R_Conv_1_4_10_1_0_1_1 L0_N491 L1_N125 1.6641635952e+05
R_Conv_1_4_10_1_0_2_0 L0_N492 L1_N125 1.1683261279e+06
R_Conv_1_4_10_1_0_2_1 L0_N493 L1_N125 1.1602008983e+05
R_Conv_1_4_10_1_1_0_0 L0_N544 L1_N125 1.2296662853e+05
R_Conv_1_4_10_1_1_0_1 L0_N545 L1_N125 1.6882235068e+05
R_Conv_1_4_10_1_1_1_0 L0_N546 L1_N125 1.0472083211e+05
R_Conv_1_4_10_1_1_1_1 L0_N547 L1_N125 2.1167619859e+05
R_Conv_1_4_10_1_1_2_0 L0_N548 L1_N125 1.3518319025e+05
R_Conv_1_4_10_1_1_2_1 L0_N549 L1_N125 1.4280846670e+05
R_Conv_1_4_10_1_2_0_0 L0_N600 L1_N125 1.1620759255e+05
R_Conv_1_4_10_1_2_0_1 L0_N601 L1_N125 1.6895116802e+05
R_Conv_1_4_10_1_2_1_0 L0_N602 L1_N125 1.2455043512e+06
R_Conv_1_4_10_1_2_1_1 L0_N603 L1_N125 1.1694022847e+05
R_Conv_1_4_10_1_2_2_0 L0_N604 L1_N125 1.5663616684e+06
R_Conv_1_4_10_1_2_2_1 L0_N605 L1_N125 2.1466641264e+05
*
R_Conv_1_4_11_0_0_0_0 L0_N492 L1_N126 3.0927915375e+05
R_Conv_1_4_11_0_0_0_1 L0_N493 L1_N126 3.6154472179e+05
R_Conv_1_4_11_0_0_1_0 L0_N494 L1_N126 1.2307612303e+05
R_Conv_1_4_11_0_0_1_1 L0_N495 L1_N126 1.3361401953e+06
R_Conv_1_4_11_0_0_2_0 L0_N496 L1_N126 1.1771240850e+06
R_Conv_1_4_11_0_0_2_1 L0_N497 L1_N126 1.1947062568e+05
R_Conv_1_4_11_0_1_0_0 L0_N548 L1_N126 3.4555602430e+05
R_Conv_1_4_11_0_1_0_1 L0_N549 L1_N126 1.2140655673e+05
R_Conv_1_4_11_0_1_1_0 L0_N550 L1_N126 2.0024008865e+05
R_Conv_1_4_11_0_1_1_1 L0_N551 L1_N126 1.3019124074e+05
R_Conv_1_4_11_0_1_2_0 L0_N552 L1_N126 1.1085089352e+05
R_Conv_1_4_11_0_1_2_1 L0_N553 L1_N126 2.5251460583e+05
R_Conv_1_4_11_0_2_0_0 L0_N604 L1_N126 1.1040315248e+05
R_Conv_1_4_11_0_2_0_1 L0_N605 L1_N126 1.2105931856e+05
R_Conv_1_4_11_0_2_1_0 L0_N606 L1_N126 1.0186236681e+05
R_Conv_1_4_11_0_2_1_1 L0_N607 L1_N126 3.8798345399e+05
R_Conv_1_4_11_0_2_2_0 L0_N608 L1_N126 4.4022254443e+06
R_Conv_1_4_11_0_2_2_1 L0_N609 L1_N126 1.5358515901e+05
*
R_Conv_1_4_11_1_0_0_0 L0_N492 L1_N127 1.2123709737e+05
R_Conv_1_4_11_1_0_0_1 L0_N493 L1_N127 1.0849154640e+05
R_Conv_1_4_11_1_0_1_0 L0_N494 L1_N127 2.0480317885e+05
R_Conv_1_4_11_1_0_1_1 L0_N495 L1_N127 1.6641635952e+05
R_Conv_1_4_11_1_0_2_0 L0_N496 L1_N127 1.1683261279e+06
R_Conv_1_4_11_1_0_2_1 L0_N497 L1_N127 1.1602008983e+05
R_Conv_1_4_11_1_1_0_0 L0_N548 L1_N127 1.2296662853e+05
R_Conv_1_4_11_1_1_0_1 L0_N549 L1_N127 1.6882235068e+05
R_Conv_1_4_11_1_1_1_0 L0_N550 L1_N127 1.0472083211e+05
R_Conv_1_4_11_1_1_1_1 L0_N551 L1_N127 2.1167619859e+05
R_Conv_1_4_11_1_1_2_0 L0_N552 L1_N127 1.3518319025e+05
R_Conv_1_4_11_1_1_2_1 L0_N553 L1_N127 1.4280846670e+05
R_Conv_1_4_11_1_2_0_0 L0_N604 L1_N127 1.1620759255e+05
R_Conv_1_4_11_1_2_0_1 L0_N605 L1_N127 1.6895116802e+05
R_Conv_1_4_11_1_2_1_0 L0_N606 L1_N127 1.2455043512e+06
R_Conv_1_4_11_1_2_1_1 L0_N607 L1_N127 1.1694022847e+05
R_Conv_1_4_11_1_2_2_0 L0_N608 L1_N127 1.5663616684e+06
R_Conv_1_4_11_1_2_2_1 L0_N609 L1_N127 2.1466641264e+05
*
R_Conv_1_4_12_0_0_0_0 L0_N496 L1_N128 3.0927915375e+05
R_Conv_1_4_12_0_0_0_1 L0_N497 L1_N128 3.6154472179e+05
R_Conv_1_4_12_0_0_1_0 L0_N498 L1_N128 1.2307612303e+05
R_Conv_1_4_12_0_0_1_1 L0_N499 L1_N128 1.3361401953e+06
R_Conv_1_4_12_0_0_2_0 L0_N500 L1_N128 1.1771240850e+06
R_Conv_1_4_12_0_0_2_1 L0_N501 L1_N128 1.1947062568e+05
R_Conv_1_4_12_0_1_0_0 L0_N552 L1_N128 3.4555602430e+05
R_Conv_1_4_12_0_1_0_1 L0_N553 L1_N128 1.2140655673e+05
R_Conv_1_4_12_0_1_1_0 L0_N554 L1_N128 2.0024008865e+05
R_Conv_1_4_12_0_1_1_1 L0_N555 L1_N128 1.3019124074e+05
R_Conv_1_4_12_0_1_2_0 L0_N556 L1_N128 1.1085089352e+05
R_Conv_1_4_12_0_1_2_1 L0_N557 L1_N128 2.5251460583e+05
R_Conv_1_4_12_0_2_0_0 L0_N608 L1_N128 1.1040315248e+05
R_Conv_1_4_12_0_2_0_1 L0_N609 L1_N128 1.2105931856e+05
R_Conv_1_4_12_0_2_1_0 L0_N610 L1_N128 1.0186236681e+05
R_Conv_1_4_12_0_2_1_1 L0_N611 L1_N128 3.8798345399e+05
R_Conv_1_4_12_0_2_2_0 L0_N612 L1_N128 4.4022254443e+06
R_Conv_1_4_12_0_2_2_1 L0_N613 L1_N128 1.5358515901e+05
*
R_Conv_1_4_12_1_0_0_0 L0_N496 L1_N129 1.2123709737e+05
R_Conv_1_4_12_1_0_0_1 L0_N497 L1_N129 1.0849154640e+05
R_Conv_1_4_12_1_0_1_0 L0_N498 L1_N129 2.0480317885e+05
R_Conv_1_4_12_1_0_1_1 L0_N499 L1_N129 1.6641635952e+05
R_Conv_1_4_12_1_0_2_0 L0_N500 L1_N129 1.1683261279e+06
R_Conv_1_4_12_1_0_2_1 L0_N501 L1_N129 1.1602008983e+05
R_Conv_1_4_12_1_1_0_0 L0_N552 L1_N129 1.2296662853e+05
R_Conv_1_4_12_1_1_0_1 L0_N553 L1_N129 1.6882235068e+05
R_Conv_1_4_12_1_1_1_0 L0_N554 L1_N129 1.0472083211e+05
R_Conv_1_4_12_1_1_1_1 L0_N555 L1_N129 2.1167619859e+05
R_Conv_1_4_12_1_1_2_0 L0_N556 L1_N129 1.3518319025e+05
R_Conv_1_4_12_1_1_2_1 L0_N557 L1_N129 1.4280846670e+05
R_Conv_1_4_12_1_2_0_0 L0_N608 L1_N129 1.1620759255e+05
R_Conv_1_4_12_1_2_0_1 L0_N609 L1_N129 1.6895116802e+05
R_Conv_1_4_12_1_2_1_0 L0_N610 L1_N129 1.2455043512e+06
R_Conv_1_4_12_1_2_1_1 L0_N611 L1_N129 1.1694022847e+05
R_Conv_1_4_12_1_2_2_0 L0_N612 L1_N129 1.5663616684e+06
R_Conv_1_4_12_1_2_2_1 L0_N613 L1_N129 2.1466641264e+05
*
R_Conv_1_5_0_0_0_0_0 L0_N560 L1_N130 3.0927915375e+05
R_Conv_1_5_0_0_0_0_1 L0_N561 L1_N130 3.6154472179e+05
R_Conv_1_5_0_0_0_1_0 L0_N562 L1_N130 1.2307612303e+05
R_Conv_1_5_0_0_0_1_1 L0_N563 L1_N130 1.3361401953e+06
R_Conv_1_5_0_0_0_2_0 L0_N564 L1_N130 1.1771240850e+06
R_Conv_1_5_0_0_0_2_1 L0_N565 L1_N130 1.1947062568e+05
R_Conv_1_5_0_0_1_0_0 L0_N616 L1_N130 3.4555602430e+05
R_Conv_1_5_0_0_1_0_1 L0_N617 L1_N130 1.2140655673e+05
R_Conv_1_5_0_0_1_1_0 L0_N618 L1_N130 2.0024008865e+05
R_Conv_1_5_0_0_1_1_1 L0_N619 L1_N130 1.3019124074e+05
R_Conv_1_5_0_0_1_2_0 L0_N620 L1_N130 1.1085089352e+05
R_Conv_1_5_0_0_1_2_1 L0_N621 L1_N130 2.5251460583e+05
R_Conv_1_5_0_0_2_0_0 L0_N672 L1_N130 1.1040315248e+05
R_Conv_1_5_0_0_2_0_1 L0_N673 L1_N130 1.2105931856e+05
R_Conv_1_5_0_0_2_1_0 L0_N674 L1_N130 1.0186236681e+05
R_Conv_1_5_0_0_2_1_1 L0_N675 L1_N130 3.8798345399e+05
R_Conv_1_5_0_0_2_2_0 L0_N676 L1_N130 4.4022254443e+06
R_Conv_1_5_0_0_2_2_1 L0_N677 L1_N130 1.5358515901e+05
*
R_Conv_1_5_0_1_0_0_0 L0_N560 L1_N131 1.2123709737e+05
R_Conv_1_5_0_1_0_0_1 L0_N561 L1_N131 1.0849154640e+05
R_Conv_1_5_0_1_0_1_0 L0_N562 L1_N131 2.0480317885e+05
R_Conv_1_5_0_1_0_1_1 L0_N563 L1_N131 1.6641635952e+05
R_Conv_1_5_0_1_0_2_0 L0_N564 L1_N131 1.1683261279e+06
R_Conv_1_5_0_1_0_2_1 L0_N565 L1_N131 1.1602008983e+05
R_Conv_1_5_0_1_1_0_0 L0_N616 L1_N131 1.2296662853e+05
R_Conv_1_5_0_1_1_0_1 L0_N617 L1_N131 1.6882235068e+05
R_Conv_1_5_0_1_1_1_0 L0_N618 L1_N131 1.0472083211e+05
R_Conv_1_5_0_1_1_1_1 L0_N619 L1_N131 2.1167619859e+05
R_Conv_1_5_0_1_1_2_0 L0_N620 L1_N131 1.3518319025e+05
R_Conv_1_5_0_1_1_2_1 L0_N621 L1_N131 1.4280846670e+05
R_Conv_1_5_0_1_2_0_0 L0_N672 L1_N131 1.1620759255e+05
R_Conv_1_5_0_1_2_0_1 L0_N673 L1_N131 1.6895116802e+05
R_Conv_1_5_0_1_2_1_0 L0_N674 L1_N131 1.2455043512e+06
R_Conv_1_5_0_1_2_1_1 L0_N675 L1_N131 1.1694022847e+05
R_Conv_1_5_0_1_2_2_0 L0_N676 L1_N131 1.5663616684e+06
R_Conv_1_5_0_1_2_2_1 L0_N677 L1_N131 2.1466641264e+05
*
R_Conv_1_5_1_0_0_0_0 L0_N564 L1_N132 3.0927915375e+05
R_Conv_1_5_1_0_0_0_1 L0_N565 L1_N132 3.6154472179e+05
R_Conv_1_5_1_0_0_1_0 L0_N566 L1_N132 1.2307612303e+05
R_Conv_1_5_1_0_0_1_1 L0_N567 L1_N132 1.3361401953e+06
R_Conv_1_5_1_0_0_2_0 L0_N568 L1_N132 1.1771240850e+06
R_Conv_1_5_1_0_0_2_1 L0_N569 L1_N132 1.1947062568e+05
R_Conv_1_5_1_0_1_0_0 L0_N620 L1_N132 3.4555602430e+05
R_Conv_1_5_1_0_1_0_1 L0_N621 L1_N132 1.2140655673e+05
R_Conv_1_5_1_0_1_1_0 L0_N622 L1_N132 2.0024008865e+05
R_Conv_1_5_1_0_1_1_1 L0_N623 L1_N132 1.3019124074e+05
R_Conv_1_5_1_0_1_2_0 L0_N624 L1_N132 1.1085089352e+05
R_Conv_1_5_1_0_1_2_1 L0_N625 L1_N132 2.5251460583e+05
R_Conv_1_5_1_0_2_0_0 L0_N676 L1_N132 1.1040315248e+05
R_Conv_1_5_1_0_2_0_1 L0_N677 L1_N132 1.2105931856e+05
R_Conv_1_5_1_0_2_1_0 L0_N678 L1_N132 1.0186236681e+05
R_Conv_1_5_1_0_2_1_1 L0_N679 L1_N132 3.8798345399e+05
R_Conv_1_5_1_0_2_2_0 L0_N680 L1_N132 4.4022254443e+06
R_Conv_1_5_1_0_2_2_1 L0_N681 L1_N132 1.5358515901e+05
*
R_Conv_1_5_1_1_0_0_0 L0_N564 L1_N133 1.2123709737e+05
R_Conv_1_5_1_1_0_0_1 L0_N565 L1_N133 1.0849154640e+05
R_Conv_1_5_1_1_0_1_0 L0_N566 L1_N133 2.0480317885e+05
R_Conv_1_5_1_1_0_1_1 L0_N567 L1_N133 1.6641635952e+05
R_Conv_1_5_1_1_0_2_0 L0_N568 L1_N133 1.1683261279e+06
R_Conv_1_5_1_1_0_2_1 L0_N569 L1_N133 1.1602008983e+05
R_Conv_1_5_1_1_1_0_0 L0_N620 L1_N133 1.2296662853e+05
R_Conv_1_5_1_1_1_0_1 L0_N621 L1_N133 1.6882235068e+05
R_Conv_1_5_1_1_1_1_0 L0_N622 L1_N133 1.0472083211e+05
R_Conv_1_5_1_1_1_1_1 L0_N623 L1_N133 2.1167619859e+05
R_Conv_1_5_1_1_1_2_0 L0_N624 L1_N133 1.3518319025e+05
R_Conv_1_5_1_1_1_2_1 L0_N625 L1_N133 1.4280846670e+05
R_Conv_1_5_1_1_2_0_0 L0_N676 L1_N133 1.1620759255e+05
R_Conv_1_5_1_1_2_0_1 L0_N677 L1_N133 1.6895116802e+05
R_Conv_1_5_1_1_2_1_0 L0_N678 L1_N133 1.2455043512e+06
R_Conv_1_5_1_1_2_1_1 L0_N679 L1_N133 1.1694022847e+05
R_Conv_1_5_1_1_2_2_0 L0_N680 L1_N133 1.5663616684e+06
R_Conv_1_5_1_1_2_2_1 L0_N681 L1_N133 2.1466641264e+05
*
R_Conv_1_5_2_0_0_0_0 L0_N568 L1_N134 3.0927915375e+05
R_Conv_1_5_2_0_0_0_1 L0_N569 L1_N134 3.6154472179e+05
R_Conv_1_5_2_0_0_1_0 L0_N570 L1_N134 1.2307612303e+05
R_Conv_1_5_2_0_0_1_1 L0_N571 L1_N134 1.3361401953e+06
R_Conv_1_5_2_0_0_2_0 L0_N572 L1_N134 1.1771240850e+06
R_Conv_1_5_2_0_0_2_1 L0_N573 L1_N134 1.1947062568e+05
R_Conv_1_5_2_0_1_0_0 L0_N624 L1_N134 3.4555602430e+05
R_Conv_1_5_2_0_1_0_1 L0_N625 L1_N134 1.2140655673e+05
R_Conv_1_5_2_0_1_1_0 L0_N626 L1_N134 2.0024008865e+05
R_Conv_1_5_2_0_1_1_1 L0_N627 L1_N134 1.3019124074e+05
R_Conv_1_5_2_0_1_2_0 L0_N628 L1_N134 1.1085089352e+05
R_Conv_1_5_2_0_1_2_1 L0_N629 L1_N134 2.5251460583e+05
R_Conv_1_5_2_0_2_0_0 L0_N680 L1_N134 1.1040315248e+05
R_Conv_1_5_2_0_2_0_1 L0_N681 L1_N134 1.2105931856e+05
R_Conv_1_5_2_0_2_1_0 L0_N682 L1_N134 1.0186236681e+05
R_Conv_1_5_2_0_2_1_1 L0_N683 L1_N134 3.8798345399e+05
R_Conv_1_5_2_0_2_2_0 L0_N684 L1_N134 4.4022254443e+06
R_Conv_1_5_2_0_2_2_1 L0_N685 L1_N134 1.5358515901e+05
*
R_Conv_1_5_2_1_0_0_0 L0_N568 L1_N135 1.2123709737e+05
R_Conv_1_5_2_1_0_0_1 L0_N569 L1_N135 1.0849154640e+05
R_Conv_1_5_2_1_0_1_0 L0_N570 L1_N135 2.0480317885e+05
R_Conv_1_5_2_1_0_1_1 L0_N571 L1_N135 1.6641635952e+05
R_Conv_1_5_2_1_0_2_0 L0_N572 L1_N135 1.1683261279e+06
R_Conv_1_5_2_1_0_2_1 L0_N573 L1_N135 1.1602008983e+05
R_Conv_1_5_2_1_1_0_0 L0_N624 L1_N135 1.2296662853e+05
R_Conv_1_5_2_1_1_0_1 L0_N625 L1_N135 1.6882235068e+05
R_Conv_1_5_2_1_1_1_0 L0_N626 L1_N135 1.0472083211e+05
R_Conv_1_5_2_1_1_1_1 L0_N627 L1_N135 2.1167619859e+05
R_Conv_1_5_2_1_1_2_0 L0_N628 L1_N135 1.3518319025e+05
R_Conv_1_5_2_1_1_2_1 L0_N629 L1_N135 1.4280846670e+05
R_Conv_1_5_2_1_2_0_0 L0_N680 L1_N135 1.1620759255e+05
R_Conv_1_5_2_1_2_0_1 L0_N681 L1_N135 1.6895116802e+05
R_Conv_1_5_2_1_2_1_0 L0_N682 L1_N135 1.2455043512e+06
R_Conv_1_5_2_1_2_1_1 L0_N683 L1_N135 1.1694022847e+05
R_Conv_1_5_2_1_2_2_0 L0_N684 L1_N135 1.5663616684e+06
R_Conv_1_5_2_1_2_2_1 L0_N685 L1_N135 2.1466641264e+05
*
R_Conv_1_5_3_0_0_0_0 L0_N572 L1_N136 3.0927915375e+05
R_Conv_1_5_3_0_0_0_1 L0_N573 L1_N136 3.6154472179e+05
R_Conv_1_5_3_0_0_1_0 L0_N574 L1_N136 1.2307612303e+05
R_Conv_1_5_3_0_0_1_1 L0_N575 L1_N136 1.3361401953e+06
R_Conv_1_5_3_0_0_2_0 L0_N576 L1_N136 1.1771240850e+06
R_Conv_1_5_3_0_0_2_1 L0_N577 L1_N136 1.1947062568e+05
R_Conv_1_5_3_0_1_0_0 L0_N628 L1_N136 3.4555602430e+05
R_Conv_1_5_3_0_1_0_1 L0_N629 L1_N136 1.2140655673e+05
R_Conv_1_5_3_0_1_1_0 L0_N630 L1_N136 2.0024008865e+05
R_Conv_1_5_3_0_1_1_1 L0_N631 L1_N136 1.3019124074e+05
R_Conv_1_5_3_0_1_2_0 L0_N632 L1_N136 1.1085089352e+05
R_Conv_1_5_3_0_1_2_1 L0_N633 L1_N136 2.5251460583e+05
R_Conv_1_5_3_0_2_0_0 L0_N684 L1_N136 1.1040315248e+05
R_Conv_1_5_3_0_2_0_1 L0_N685 L1_N136 1.2105931856e+05
R_Conv_1_5_3_0_2_1_0 L0_N686 L1_N136 1.0186236681e+05
R_Conv_1_5_3_0_2_1_1 L0_N687 L1_N136 3.8798345399e+05
R_Conv_1_5_3_0_2_2_0 L0_N688 L1_N136 4.4022254443e+06
R_Conv_1_5_3_0_2_2_1 L0_N689 L1_N136 1.5358515901e+05
*
R_Conv_1_5_3_1_0_0_0 L0_N572 L1_N137 1.2123709737e+05
R_Conv_1_5_3_1_0_0_1 L0_N573 L1_N137 1.0849154640e+05
R_Conv_1_5_3_1_0_1_0 L0_N574 L1_N137 2.0480317885e+05
R_Conv_1_5_3_1_0_1_1 L0_N575 L1_N137 1.6641635952e+05
R_Conv_1_5_3_1_0_2_0 L0_N576 L1_N137 1.1683261279e+06
R_Conv_1_5_3_1_0_2_1 L0_N577 L1_N137 1.1602008983e+05
R_Conv_1_5_3_1_1_0_0 L0_N628 L1_N137 1.2296662853e+05
R_Conv_1_5_3_1_1_0_1 L0_N629 L1_N137 1.6882235068e+05
R_Conv_1_5_3_1_1_1_0 L0_N630 L1_N137 1.0472083211e+05
R_Conv_1_5_3_1_1_1_1 L0_N631 L1_N137 2.1167619859e+05
R_Conv_1_5_3_1_1_2_0 L0_N632 L1_N137 1.3518319025e+05
R_Conv_1_5_3_1_1_2_1 L0_N633 L1_N137 1.4280846670e+05
R_Conv_1_5_3_1_2_0_0 L0_N684 L1_N137 1.1620759255e+05
R_Conv_1_5_3_1_2_0_1 L0_N685 L1_N137 1.6895116802e+05
R_Conv_1_5_3_1_2_1_0 L0_N686 L1_N137 1.2455043512e+06
R_Conv_1_5_3_1_2_1_1 L0_N687 L1_N137 1.1694022847e+05
R_Conv_1_5_3_1_2_2_0 L0_N688 L1_N137 1.5663616684e+06
R_Conv_1_5_3_1_2_2_1 L0_N689 L1_N137 2.1466641264e+05
*
R_Conv_1_5_4_0_0_0_0 L0_N576 L1_N138 3.0927915375e+05
R_Conv_1_5_4_0_0_0_1 L0_N577 L1_N138 3.6154472179e+05
R_Conv_1_5_4_0_0_1_0 L0_N578 L1_N138 1.2307612303e+05
R_Conv_1_5_4_0_0_1_1 L0_N579 L1_N138 1.3361401953e+06
R_Conv_1_5_4_0_0_2_0 L0_N580 L1_N138 1.1771240850e+06
R_Conv_1_5_4_0_0_2_1 L0_N581 L1_N138 1.1947062568e+05
R_Conv_1_5_4_0_1_0_0 L0_N632 L1_N138 3.4555602430e+05
R_Conv_1_5_4_0_1_0_1 L0_N633 L1_N138 1.2140655673e+05
R_Conv_1_5_4_0_1_1_0 L0_N634 L1_N138 2.0024008865e+05
R_Conv_1_5_4_0_1_1_1 L0_N635 L1_N138 1.3019124074e+05
R_Conv_1_5_4_0_1_2_0 L0_N636 L1_N138 1.1085089352e+05
R_Conv_1_5_4_0_1_2_1 L0_N637 L1_N138 2.5251460583e+05
R_Conv_1_5_4_0_2_0_0 L0_N688 L1_N138 1.1040315248e+05
R_Conv_1_5_4_0_2_0_1 L0_N689 L1_N138 1.2105931856e+05
R_Conv_1_5_4_0_2_1_0 L0_N690 L1_N138 1.0186236681e+05
R_Conv_1_5_4_0_2_1_1 L0_N691 L1_N138 3.8798345399e+05
R_Conv_1_5_4_0_2_2_0 L0_N692 L1_N138 4.4022254443e+06
R_Conv_1_5_4_0_2_2_1 L0_N693 L1_N138 1.5358515901e+05
*
R_Conv_1_5_4_1_0_0_0 L0_N576 L1_N139 1.2123709737e+05
R_Conv_1_5_4_1_0_0_1 L0_N577 L1_N139 1.0849154640e+05
R_Conv_1_5_4_1_0_1_0 L0_N578 L1_N139 2.0480317885e+05
R_Conv_1_5_4_1_0_1_1 L0_N579 L1_N139 1.6641635952e+05
R_Conv_1_5_4_1_0_2_0 L0_N580 L1_N139 1.1683261279e+06
R_Conv_1_5_4_1_0_2_1 L0_N581 L1_N139 1.1602008983e+05
R_Conv_1_5_4_1_1_0_0 L0_N632 L1_N139 1.2296662853e+05
R_Conv_1_5_4_1_1_0_1 L0_N633 L1_N139 1.6882235068e+05
R_Conv_1_5_4_1_1_1_0 L0_N634 L1_N139 1.0472083211e+05
R_Conv_1_5_4_1_1_1_1 L0_N635 L1_N139 2.1167619859e+05
R_Conv_1_5_4_1_1_2_0 L0_N636 L1_N139 1.3518319025e+05
R_Conv_1_5_4_1_1_2_1 L0_N637 L1_N139 1.4280846670e+05
R_Conv_1_5_4_1_2_0_0 L0_N688 L1_N139 1.1620759255e+05
R_Conv_1_5_4_1_2_0_1 L0_N689 L1_N139 1.6895116802e+05
R_Conv_1_5_4_1_2_1_0 L0_N690 L1_N139 1.2455043512e+06
R_Conv_1_5_4_1_2_1_1 L0_N691 L1_N139 1.1694022847e+05
R_Conv_1_5_4_1_2_2_0 L0_N692 L1_N139 1.5663616684e+06
R_Conv_1_5_4_1_2_2_1 L0_N693 L1_N139 2.1466641264e+05
*
R_Conv_1_5_5_0_0_0_0 L0_N580 L1_N140 3.0927915375e+05
R_Conv_1_5_5_0_0_0_1 L0_N581 L1_N140 3.6154472179e+05
R_Conv_1_5_5_0_0_1_0 L0_N582 L1_N140 1.2307612303e+05
R_Conv_1_5_5_0_0_1_1 L0_N583 L1_N140 1.3361401953e+06
R_Conv_1_5_5_0_0_2_0 L0_N584 L1_N140 1.1771240850e+06
R_Conv_1_5_5_0_0_2_1 L0_N585 L1_N140 1.1947062568e+05
R_Conv_1_5_5_0_1_0_0 L0_N636 L1_N140 3.4555602430e+05
R_Conv_1_5_5_0_1_0_1 L0_N637 L1_N140 1.2140655673e+05
R_Conv_1_5_5_0_1_1_0 L0_N638 L1_N140 2.0024008865e+05
R_Conv_1_5_5_0_1_1_1 L0_N639 L1_N140 1.3019124074e+05
R_Conv_1_5_5_0_1_2_0 L0_N640 L1_N140 1.1085089352e+05
R_Conv_1_5_5_0_1_2_1 L0_N641 L1_N140 2.5251460583e+05
R_Conv_1_5_5_0_2_0_0 L0_N692 L1_N140 1.1040315248e+05
R_Conv_1_5_5_0_2_0_1 L0_N693 L1_N140 1.2105931856e+05
R_Conv_1_5_5_0_2_1_0 L0_N694 L1_N140 1.0186236681e+05
R_Conv_1_5_5_0_2_1_1 L0_N695 L1_N140 3.8798345399e+05
R_Conv_1_5_5_0_2_2_0 L0_N696 L1_N140 4.4022254443e+06
R_Conv_1_5_5_0_2_2_1 L0_N697 L1_N140 1.5358515901e+05
*
R_Conv_1_5_5_1_0_0_0 L0_N580 L1_N141 1.2123709737e+05
R_Conv_1_5_5_1_0_0_1 L0_N581 L1_N141 1.0849154640e+05
R_Conv_1_5_5_1_0_1_0 L0_N582 L1_N141 2.0480317885e+05
R_Conv_1_5_5_1_0_1_1 L0_N583 L1_N141 1.6641635952e+05
R_Conv_1_5_5_1_0_2_0 L0_N584 L1_N141 1.1683261279e+06
R_Conv_1_5_5_1_0_2_1 L0_N585 L1_N141 1.1602008983e+05
R_Conv_1_5_5_1_1_0_0 L0_N636 L1_N141 1.2296662853e+05
R_Conv_1_5_5_1_1_0_1 L0_N637 L1_N141 1.6882235068e+05
R_Conv_1_5_5_1_1_1_0 L0_N638 L1_N141 1.0472083211e+05
R_Conv_1_5_5_1_1_1_1 L0_N639 L1_N141 2.1167619859e+05
R_Conv_1_5_5_1_1_2_0 L0_N640 L1_N141 1.3518319025e+05
R_Conv_1_5_5_1_1_2_1 L0_N641 L1_N141 1.4280846670e+05
R_Conv_1_5_5_1_2_0_0 L0_N692 L1_N141 1.1620759255e+05
R_Conv_1_5_5_1_2_0_1 L0_N693 L1_N141 1.6895116802e+05
R_Conv_1_5_5_1_2_1_0 L0_N694 L1_N141 1.2455043512e+06
R_Conv_1_5_5_1_2_1_1 L0_N695 L1_N141 1.1694022847e+05
R_Conv_1_5_5_1_2_2_0 L0_N696 L1_N141 1.5663616684e+06
R_Conv_1_5_5_1_2_2_1 L0_N697 L1_N141 2.1466641264e+05
*
R_Conv_1_5_6_0_0_0_0 L0_N584 L1_N142 3.0927915375e+05
R_Conv_1_5_6_0_0_0_1 L0_N585 L1_N142 3.6154472179e+05
R_Conv_1_5_6_0_0_1_0 L0_N586 L1_N142 1.2307612303e+05
R_Conv_1_5_6_0_0_1_1 L0_N587 L1_N142 1.3361401953e+06
R_Conv_1_5_6_0_0_2_0 L0_N588 L1_N142 1.1771240850e+06
R_Conv_1_5_6_0_0_2_1 L0_N589 L1_N142 1.1947062568e+05
R_Conv_1_5_6_0_1_0_0 L0_N640 L1_N142 3.4555602430e+05
R_Conv_1_5_6_0_1_0_1 L0_N641 L1_N142 1.2140655673e+05
R_Conv_1_5_6_0_1_1_0 L0_N642 L1_N142 2.0024008865e+05
R_Conv_1_5_6_0_1_1_1 L0_N643 L1_N142 1.3019124074e+05
R_Conv_1_5_6_0_1_2_0 L0_N644 L1_N142 1.1085089352e+05
R_Conv_1_5_6_0_1_2_1 L0_N645 L1_N142 2.5251460583e+05
R_Conv_1_5_6_0_2_0_0 L0_N696 L1_N142 1.1040315248e+05
R_Conv_1_5_6_0_2_0_1 L0_N697 L1_N142 1.2105931856e+05
R_Conv_1_5_6_0_2_1_0 L0_N698 L1_N142 1.0186236681e+05
R_Conv_1_5_6_0_2_1_1 L0_N699 L1_N142 3.8798345399e+05
R_Conv_1_5_6_0_2_2_0 L0_N700 L1_N142 4.4022254443e+06
R_Conv_1_5_6_0_2_2_1 L0_N701 L1_N142 1.5358515901e+05
*
R_Conv_1_5_6_1_0_0_0 L0_N584 L1_N143 1.2123709737e+05
R_Conv_1_5_6_1_0_0_1 L0_N585 L1_N143 1.0849154640e+05
R_Conv_1_5_6_1_0_1_0 L0_N586 L1_N143 2.0480317885e+05
R_Conv_1_5_6_1_0_1_1 L0_N587 L1_N143 1.6641635952e+05
R_Conv_1_5_6_1_0_2_0 L0_N588 L1_N143 1.1683261279e+06
R_Conv_1_5_6_1_0_2_1 L0_N589 L1_N143 1.1602008983e+05
R_Conv_1_5_6_1_1_0_0 L0_N640 L1_N143 1.2296662853e+05
R_Conv_1_5_6_1_1_0_1 L0_N641 L1_N143 1.6882235068e+05
R_Conv_1_5_6_1_1_1_0 L0_N642 L1_N143 1.0472083211e+05
R_Conv_1_5_6_1_1_1_1 L0_N643 L1_N143 2.1167619859e+05
R_Conv_1_5_6_1_1_2_0 L0_N644 L1_N143 1.3518319025e+05
R_Conv_1_5_6_1_1_2_1 L0_N645 L1_N143 1.4280846670e+05
R_Conv_1_5_6_1_2_0_0 L0_N696 L1_N143 1.1620759255e+05
R_Conv_1_5_6_1_2_0_1 L0_N697 L1_N143 1.6895116802e+05
R_Conv_1_5_6_1_2_1_0 L0_N698 L1_N143 1.2455043512e+06
R_Conv_1_5_6_1_2_1_1 L0_N699 L1_N143 1.1694022847e+05
R_Conv_1_5_6_1_2_2_0 L0_N700 L1_N143 1.5663616684e+06
R_Conv_1_5_6_1_2_2_1 L0_N701 L1_N143 2.1466641264e+05
*
R_Conv_1_5_7_0_0_0_0 L0_N588 L1_N144 3.0927915375e+05
R_Conv_1_5_7_0_0_0_1 L0_N589 L1_N144 3.6154472179e+05
R_Conv_1_5_7_0_0_1_0 L0_N590 L1_N144 1.2307612303e+05
R_Conv_1_5_7_0_0_1_1 L0_N591 L1_N144 1.3361401953e+06
R_Conv_1_5_7_0_0_2_0 L0_N592 L1_N144 1.1771240850e+06
R_Conv_1_5_7_0_0_2_1 L0_N593 L1_N144 1.1947062568e+05
R_Conv_1_5_7_0_1_0_0 L0_N644 L1_N144 3.4555602430e+05
R_Conv_1_5_7_0_1_0_1 L0_N645 L1_N144 1.2140655673e+05
R_Conv_1_5_7_0_1_1_0 L0_N646 L1_N144 2.0024008865e+05
R_Conv_1_5_7_0_1_1_1 L0_N647 L1_N144 1.3019124074e+05
R_Conv_1_5_7_0_1_2_0 L0_N648 L1_N144 1.1085089352e+05
R_Conv_1_5_7_0_1_2_1 L0_N649 L1_N144 2.5251460583e+05
R_Conv_1_5_7_0_2_0_0 L0_N700 L1_N144 1.1040315248e+05
R_Conv_1_5_7_0_2_0_1 L0_N701 L1_N144 1.2105931856e+05
R_Conv_1_5_7_0_2_1_0 L0_N702 L1_N144 1.0186236681e+05
R_Conv_1_5_7_0_2_1_1 L0_N703 L1_N144 3.8798345399e+05
R_Conv_1_5_7_0_2_2_0 L0_N704 L1_N144 4.4022254443e+06
R_Conv_1_5_7_0_2_2_1 L0_N705 L1_N144 1.5358515901e+05
*
R_Conv_1_5_7_1_0_0_0 L0_N588 L1_N145 1.2123709737e+05
R_Conv_1_5_7_1_0_0_1 L0_N589 L1_N145 1.0849154640e+05
R_Conv_1_5_7_1_0_1_0 L0_N590 L1_N145 2.0480317885e+05
R_Conv_1_5_7_1_0_1_1 L0_N591 L1_N145 1.6641635952e+05
R_Conv_1_5_7_1_0_2_0 L0_N592 L1_N145 1.1683261279e+06
R_Conv_1_5_7_1_0_2_1 L0_N593 L1_N145 1.1602008983e+05
R_Conv_1_5_7_1_1_0_0 L0_N644 L1_N145 1.2296662853e+05
R_Conv_1_5_7_1_1_0_1 L0_N645 L1_N145 1.6882235068e+05
R_Conv_1_5_7_1_1_1_0 L0_N646 L1_N145 1.0472083211e+05
R_Conv_1_5_7_1_1_1_1 L0_N647 L1_N145 2.1167619859e+05
R_Conv_1_5_7_1_1_2_0 L0_N648 L1_N145 1.3518319025e+05
R_Conv_1_5_7_1_1_2_1 L0_N649 L1_N145 1.4280846670e+05
R_Conv_1_5_7_1_2_0_0 L0_N700 L1_N145 1.1620759255e+05
R_Conv_1_5_7_1_2_0_1 L0_N701 L1_N145 1.6895116802e+05
R_Conv_1_5_7_1_2_1_0 L0_N702 L1_N145 1.2455043512e+06
R_Conv_1_5_7_1_2_1_1 L0_N703 L1_N145 1.1694022847e+05
R_Conv_1_5_7_1_2_2_0 L0_N704 L1_N145 1.5663616684e+06
R_Conv_1_5_7_1_2_2_1 L0_N705 L1_N145 2.1466641264e+05
*
R_Conv_1_5_8_0_0_0_0 L0_N592 L1_N146 3.0927915375e+05
R_Conv_1_5_8_0_0_0_1 L0_N593 L1_N146 3.6154472179e+05
R_Conv_1_5_8_0_0_1_0 L0_N594 L1_N146 1.2307612303e+05
R_Conv_1_5_8_0_0_1_1 L0_N595 L1_N146 1.3361401953e+06
R_Conv_1_5_8_0_0_2_0 L0_N596 L1_N146 1.1771240850e+06
R_Conv_1_5_8_0_0_2_1 L0_N597 L1_N146 1.1947062568e+05
R_Conv_1_5_8_0_1_0_0 L0_N648 L1_N146 3.4555602430e+05
R_Conv_1_5_8_0_1_0_1 L0_N649 L1_N146 1.2140655673e+05
R_Conv_1_5_8_0_1_1_0 L0_N650 L1_N146 2.0024008865e+05
R_Conv_1_5_8_0_1_1_1 L0_N651 L1_N146 1.3019124074e+05
R_Conv_1_5_8_0_1_2_0 L0_N652 L1_N146 1.1085089352e+05
R_Conv_1_5_8_0_1_2_1 L0_N653 L1_N146 2.5251460583e+05
R_Conv_1_5_8_0_2_0_0 L0_N704 L1_N146 1.1040315248e+05
R_Conv_1_5_8_0_2_0_1 L0_N705 L1_N146 1.2105931856e+05
R_Conv_1_5_8_0_2_1_0 L0_N706 L1_N146 1.0186236681e+05
R_Conv_1_5_8_0_2_1_1 L0_N707 L1_N146 3.8798345399e+05
R_Conv_1_5_8_0_2_2_0 L0_N708 L1_N146 4.4022254443e+06
R_Conv_1_5_8_0_2_2_1 L0_N709 L1_N146 1.5358515901e+05
*
R_Conv_1_5_8_1_0_0_0 L0_N592 L1_N147 1.2123709737e+05
R_Conv_1_5_8_1_0_0_1 L0_N593 L1_N147 1.0849154640e+05
R_Conv_1_5_8_1_0_1_0 L0_N594 L1_N147 2.0480317885e+05
R_Conv_1_5_8_1_0_1_1 L0_N595 L1_N147 1.6641635952e+05
R_Conv_1_5_8_1_0_2_0 L0_N596 L1_N147 1.1683261279e+06
R_Conv_1_5_8_1_0_2_1 L0_N597 L1_N147 1.1602008983e+05
R_Conv_1_5_8_1_1_0_0 L0_N648 L1_N147 1.2296662853e+05
R_Conv_1_5_8_1_1_0_1 L0_N649 L1_N147 1.6882235068e+05
R_Conv_1_5_8_1_1_1_0 L0_N650 L1_N147 1.0472083211e+05
R_Conv_1_5_8_1_1_1_1 L0_N651 L1_N147 2.1167619859e+05
R_Conv_1_5_8_1_1_2_0 L0_N652 L1_N147 1.3518319025e+05
R_Conv_1_5_8_1_1_2_1 L0_N653 L1_N147 1.4280846670e+05
R_Conv_1_5_8_1_2_0_0 L0_N704 L1_N147 1.1620759255e+05
R_Conv_1_5_8_1_2_0_1 L0_N705 L1_N147 1.6895116802e+05
R_Conv_1_5_8_1_2_1_0 L0_N706 L1_N147 1.2455043512e+06
R_Conv_1_5_8_1_2_1_1 L0_N707 L1_N147 1.1694022847e+05
R_Conv_1_5_8_1_2_2_0 L0_N708 L1_N147 1.5663616684e+06
R_Conv_1_5_8_1_2_2_1 L0_N709 L1_N147 2.1466641264e+05
*
R_Conv_1_5_9_0_0_0_0 L0_N596 L1_N148 3.0927915375e+05
R_Conv_1_5_9_0_0_0_1 L0_N597 L1_N148 3.6154472179e+05
R_Conv_1_5_9_0_0_1_0 L0_N598 L1_N148 1.2307612303e+05
R_Conv_1_5_9_0_0_1_1 L0_N599 L1_N148 1.3361401953e+06
R_Conv_1_5_9_0_0_2_0 L0_N600 L1_N148 1.1771240850e+06
R_Conv_1_5_9_0_0_2_1 L0_N601 L1_N148 1.1947062568e+05
R_Conv_1_5_9_0_1_0_0 L0_N652 L1_N148 3.4555602430e+05
R_Conv_1_5_9_0_1_0_1 L0_N653 L1_N148 1.2140655673e+05
R_Conv_1_5_9_0_1_1_0 L0_N654 L1_N148 2.0024008865e+05
R_Conv_1_5_9_0_1_1_1 L0_N655 L1_N148 1.3019124074e+05
R_Conv_1_5_9_0_1_2_0 L0_N656 L1_N148 1.1085089352e+05
R_Conv_1_5_9_0_1_2_1 L0_N657 L1_N148 2.5251460583e+05
R_Conv_1_5_9_0_2_0_0 L0_N708 L1_N148 1.1040315248e+05
R_Conv_1_5_9_0_2_0_1 L0_N709 L1_N148 1.2105931856e+05
R_Conv_1_5_9_0_2_1_0 L0_N710 L1_N148 1.0186236681e+05
R_Conv_1_5_9_0_2_1_1 L0_N711 L1_N148 3.8798345399e+05
R_Conv_1_5_9_0_2_2_0 L0_N712 L1_N148 4.4022254443e+06
R_Conv_1_5_9_0_2_2_1 L0_N713 L1_N148 1.5358515901e+05
*
R_Conv_1_5_9_1_0_0_0 L0_N596 L1_N149 1.2123709737e+05
R_Conv_1_5_9_1_0_0_1 L0_N597 L1_N149 1.0849154640e+05
R_Conv_1_5_9_1_0_1_0 L0_N598 L1_N149 2.0480317885e+05
R_Conv_1_5_9_1_0_1_1 L0_N599 L1_N149 1.6641635952e+05
R_Conv_1_5_9_1_0_2_0 L0_N600 L1_N149 1.1683261279e+06
R_Conv_1_5_9_1_0_2_1 L0_N601 L1_N149 1.1602008983e+05
R_Conv_1_5_9_1_1_0_0 L0_N652 L1_N149 1.2296662853e+05
R_Conv_1_5_9_1_1_0_1 L0_N653 L1_N149 1.6882235068e+05
R_Conv_1_5_9_1_1_1_0 L0_N654 L1_N149 1.0472083211e+05
R_Conv_1_5_9_1_1_1_1 L0_N655 L1_N149 2.1167619859e+05
R_Conv_1_5_9_1_1_2_0 L0_N656 L1_N149 1.3518319025e+05
R_Conv_1_5_9_1_1_2_1 L0_N657 L1_N149 1.4280846670e+05
R_Conv_1_5_9_1_2_0_0 L0_N708 L1_N149 1.1620759255e+05
R_Conv_1_5_9_1_2_0_1 L0_N709 L1_N149 1.6895116802e+05
R_Conv_1_5_9_1_2_1_0 L0_N710 L1_N149 1.2455043512e+06
R_Conv_1_5_9_1_2_1_1 L0_N711 L1_N149 1.1694022847e+05
R_Conv_1_5_9_1_2_2_0 L0_N712 L1_N149 1.5663616684e+06
R_Conv_1_5_9_1_2_2_1 L0_N713 L1_N149 2.1466641264e+05
*
R_Conv_1_5_10_0_0_0_0 L0_N600 L1_N150 3.0927915375e+05
R_Conv_1_5_10_0_0_0_1 L0_N601 L1_N150 3.6154472179e+05
R_Conv_1_5_10_0_0_1_0 L0_N602 L1_N150 1.2307612303e+05
R_Conv_1_5_10_0_0_1_1 L0_N603 L1_N150 1.3361401953e+06
R_Conv_1_5_10_0_0_2_0 L0_N604 L1_N150 1.1771240850e+06
R_Conv_1_5_10_0_0_2_1 L0_N605 L1_N150 1.1947062568e+05
R_Conv_1_5_10_0_1_0_0 L0_N656 L1_N150 3.4555602430e+05
R_Conv_1_5_10_0_1_0_1 L0_N657 L1_N150 1.2140655673e+05
R_Conv_1_5_10_0_1_1_0 L0_N658 L1_N150 2.0024008865e+05
R_Conv_1_5_10_0_1_1_1 L0_N659 L1_N150 1.3019124074e+05
R_Conv_1_5_10_0_1_2_0 L0_N660 L1_N150 1.1085089352e+05
R_Conv_1_5_10_0_1_2_1 L0_N661 L1_N150 2.5251460583e+05
R_Conv_1_5_10_0_2_0_0 L0_N712 L1_N150 1.1040315248e+05
R_Conv_1_5_10_0_2_0_1 L0_N713 L1_N150 1.2105931856e+05
R_Conv_1_5_10_0_2_1_0 L0_N714 L1_N150 1.0186236681e+05
R_Conv_1_5_10_0_2_1_1 L0_N715 L1_N150 3.8798345399e+05
R_Conv_1_5_10_0_2_2_0 L0_N716 L1_N150 4.4022254443e+06
R_Conv_1_5_10_0_2_2_1 L0_N717 L1_N150 1.5358515901e+05
*
R_Conv_1_5_10_1_0_0_0 L0_N600 L1_N151 1.2123709737e+05
R_Conv_1_5_10_1_0_0_1 L0_N601 L1_N151 1.0849154640e+05
R_Conv_1_5_10_1_0_1_0 L0_N602 L1_N151 2.0480317885e+05
R_Conv_1_5_10_1_0_1_1 L0_N603 L1_N151 1.6641635952e+05
R_Conv_1_5_10_1_0_2_0 L0_N604 L1_N151 1.1683261279e+06
R_Conv_1_5_10_1_0_2_1 L0_N605 L1_N151 1.1602008983e+05
R_Conv_1_5_10_1_1_0_0 L0_N656 L1_N151 1.2296662853e+05
R_Conv_1_5_10_1_1_0_1 L0_N657 L1_N151 1.6882235068e+05
R_Conv_1_5_10_1_1_1_0 L0_N658 L1_N151 1.0472083211e+05
R_Conv_1_5_10_1_1_1_1 L0_N659 L1_N151 2.1167619859e+05
R_Conv_1_5_10_1_1_2_0 L0_N660 L1_N151 1.3518319025e+05
R_Conv_1_5_10_1_1_2_1 L0_N661 L1_N151 1.4280846670e+05
R_Conv_1_5_10_1_2_0_0 L0_N712 L1_N151 1.1620759255e+05
R_Conv_1_5_10_1_2_0_1 L0_N713 L1_N151 1.6895116802e+05
R_Conv_1_5_10_1_2_1_0 L0_N714 L1_N151 1.2455043512e+06
R_Conv_1_5_10_1_2_1_1 L0_N715 L1_N151 1.1694022847e+05
R_Conv_1_5_10_1_2_2_0 L0_N716 L1_N151 1.5663616684e+06
R_Conv_1_5_10_1_2_2_1 L0_N717 L1_N151 2.1466641264e+05
*
R_Conv_1_5_11_0_0_0_0 L0_N604 L1_N152 3.0927915375e+05
R_Conv_1_5_11_0_0_0_1 L0_N605 L1_N152 3.6154472179e+05
R_Conv_1_5_11_0_0_1_0 L0_N606 L1_N152 1.2307612303e+05
R_Conv_1_5_11_0_0_1_1 L0_N607 L1_N152 1.3361401953e+06
R_Conv_1_5_11_0_0_2_0 L0_N608 L1_N152 1.1771240850e+06
R_Conv_1_5_11_0_0_2_1 L0_N609 L1_N152 1.1947062568e+05
R_Conv_1_5_11_0_1_0_0 L0_N660 L1_N152 3.4555602430e+05
R_Conv_1_5_11_0_1_0_1 L0_N661 L1_N152 1.2140655673e+05
R_Conv_1_5_11_0_1_1_0 L0_N662 L1_N152 2.0024008865e+05
R_Conv_1_5_11_0_1_1_1 L0_N663 L1_N152 1.3019124074e+05
R_Conv_1_5_11_0_1_2_0 L0_N664 L1_N152 1.1085089352e+05
R_Conv_1_5_11_0_1_2_1 L0_N665 L1_N152 2.5251460583e+05
R_Conv_1_5_11_0_2_0_0 L0_N716 L1_N152 1.1040315248e+05
R_Conv_1_5_11_0_2_0_1 L0_N717 L1_N152 1.2105931856e+05
R_Conv_1_5_11_0_2_1_0 L0_N718 L1_N152 1.0186236681e+05
R_Conv_1_5_11_0_2_1_1 L0_N719 L1_N152 3.8798345399e+05
R_Conv_1_5_11_0_2_2_0 L0_N720 L1_N152 4.4022254443e+06
R_Conv_1_5_11_0_2_2_1 L0_N721 L1_N152 1.5358515901e+05
*
R_Conv_1_5_11_1_0_0_0 L0_N604 L1_N153 1.2123709737e+05
R_Conv_1_5_11_1_0_0_1 L0_N605 L1_N153 1.0849154640e+05
R_Conv_1_5_11_1_0_1_0 L0_N606 L1_N153 2.0480317885e+05
R_Conv_1_5_11_1_0_1_1 L0_N607 L1_N153 1.6641635952e+05
R_Conv_1_5_11_1_0_2_0 L0_N608 L1_N153 1.1683261279e+06
R_Conv_1_5_11_1_0_2_1 L0_N609 L1_N153 1.1602008983e+05
R_Conv_1_5_11_1_1_0_0 L0_N660 L1_N153 1.2296662853e+05
R_Conv_1_5_11_1_1_0_1 L0_N661 L1_N153 1.6882235068e+05
R_Conv_1_5_11_1_1_1_0 L0_N662 L1_N153 1.0472083211e+05
R_Conv_1_5_11_1_1_1_1 L0_N663 L1_N153 2.1167619859e+05
R_Conv_1_5_11_1_1_2_0 L0_N664 L1_N153 1.3518319025e+05
R_Conv_1_5_11_1_1_2_1 L0_N665 L1_N153 1.4280846670e+05
R_Conv_1_5_11_1_2_0_0 L0_N716 L1_N153 1.1620759255e+05
R_Conv_1_5_11_1_2_0_1 L0_N717 L1_N153 1.6895116802e+05
R_Conv_1_5_11_1_2_1_0 L0_N718 L1_N153 1.2455043512e+06
R_Conv_1_5_11_1_2_1_1 L0_N719 L1_N153 1.1694022847e+05
R_Conv_1_5_11_1_2_2_0 L0_N720 L1_N153 1.5663616684e+06
R_Conv_1_5_11_1_2_2_1 L0_N721 L1_N153 2.1466641264e+05
*
R_Conv_1_5_12_0_0_0_0 L0_N608 L1_N154 3.0927915375e+05
R_Conv_1_5_12_0_0_0_1 L0_N609 L1_N154 3.6154472179e+05
R_Conv_1_5_12_0_0_1_0 L0_N610 L1_N154 1.2307612303e+05
R_Conv_1_5_12_0_0_1_1 L0_N611 L1_N154 1.3361401953e+06
R_Conv_1_5_12_0_0_2_0 L0_N612 L1_N154 1.1771240850e+06
R_Conv_1_5_12_0_0_2_1 L0_N613 L1_N154 1.1947062568e+05
R_Conv_1_5_12_0_1_0_0 L0_N664 L1_N154 3.4555602430e+05
R_Conv_1_5_12_0_1_0_1 L0_N665 L1_N154 1.2140655673e+05
R_Conv_1_5_12_0_1_1_0 L0_N666 L1_N154 2.0024008865e+05
R_Conv_1_5_12_0_1_1_1 L0_N667 L1_N154 1.3019124074e+05
R_Conv_1_5_12_0_1_2_0 L0_N668 L1_N154 1.1085089352e+05
R_Conv_1_5_12_0_1_2_1 L0_N669 L1_N154 2.5251460583e+05
R_Conv_1_5_12_0_2_0_0 L0_N720 L1_N154 1.1040315248e+05
R_Conv_1_5_12_0_2_0_1 L0_N721 L1_N154 1.2105931856e+05
R_Conv_1_5_12_0_2_1_0 L0_N722 L1_N154 1.0186236681e+05
R_Conv_1_5_12_0_2_1_1 L0_N723 L1_N154 3.8798345399e+05
R_Conv_1_5_12_0_2_2_0 L0_N724 L1_N154 4.4022254443e+06
R_Conv_1_5_12_0_2_2_1 L0_N725 L1_N154 1.5358515901e+05
*
R_Conv_1_5_12_1_0_0_0 L0_N608 L1_N155 1.2123709737e+05
R_Conv_1_5_12_1_0_0_1 L0_N609 L1_N155 1.0849154640e+05
R_Conv_1_5_12_1_0_1_0 L0_N610 L1_N155 2.0480317885e+05
R_Conv_1_5_12_1_0_1_1 L0_N611 L1_N155 1.6641635952e+05
R_Conv_1_5_12_1_0_2_0 L0_N612 L1_N155 1.1683261279e+06
R_Conv_1_5_12_1_0_2_1 L0_N613 L1_N155 1.1602008983e+05
R_Conv_1_5_12_1_1_0_0 L0_N664 L1_N155 1.2296662853e+05
R_Conv_1_5_12_1_1_0_1 L0_N665 L1_N155 1.6882235068e+05
R_Conv_1_5_12_1_1_1_0 L0_N666 L1_N155 1.0472083211e+05
R_Conv_1_5_12_1_1_1_1 L0_N667 L1_N155 2.1167619859e+05
R_Conv_1_5_12_1_1_2_0 L0_N668 L1_N155 1.3518319025e+05
R_Conv_1_5_12_1_1_2_1 L0_N669 L1_N155 1.4280846670e+05
R_Conv_1_5_12_1_2_0_0 L0_N720 L1_N155 1.1620759255e+05
R_Conv_1_5_12_1_2_0_1 L0_N721 L1_N155 1.6895116802e+05
R_Conv_1_5_12_1_2_1_0 L0_N722 L1_N155 1.2455043512e+06
R_Conv_1_5_12_1_2_1_1 L0_N723 L1_N155 1.1694022847e+05
R_Conv_1_5_12_1_2_2_0 L0_N724 L1_N155 1.5663616684e+06
R_Conv_1_5_12_1_2_2_1 L0_N725 L1_N155 2.1466641264e+05
*
R_Conv_1_6_0_0_0_0_0 L0_N672 L1_N156 3.0927915375e+05
R_Conv_1_6_0_0_0_0_1 L0_N673 L1_N156 3.6154472179e+05
R_Conv_1_6_0_0_0_1_0 L0_N674 L1_N156 1.2307612303e+05
R_Conv_1_6_0_0_0_1_1 L0_N675 L1_N156 1.3361401953e+06
R_Conv_1_6_0_0_0_2_0 L0_N676 L1_N156 1.1771240850e+06
R_Conv_1_6_0_0_0_2_1 L0_N677 L1_N156 1.1947062568e+05
R_Conv_1_6_0_0_1_0_0 L0_N728 L1_N156 3.4555602430e+05
R_Conv_1_6_0_0_1_0_1 L0_N729 L1_N156 1.2140655673e+05
R_Conv_1_6_0_0_1_1_0 L0_N730 L1_N156 2.0024008865e+05
R_Conv_1_6_0_0_1_1_1 L0_N731 L1_N156 1.3019124074e+05
R_Conv_1_6_0_0_1_2_0 L0_N732 L1_N156 1.1085089352e+05
R_Conv_1_6_0_0_1_2_1 L0_N733 L1_N156 2.5251460583e+05
R_Conv_1_6_0_0_2_0_0 L0_N784 L1_N156 1.1040315248e+05
R_Conv_1_6_0_0_2_0_1 L0_N785 L1_N156 1.2105931856e+05
R_Conv_1_6_0_0_2_1_0 L0_N786 L1_N156 1.0186236681e+05
R_Conv_1_6_0_0_2_1_1 L0_N787 L1_N156 3.8798345399e+05
R_Conv_1_6_0_0_2_2_0 L0_N788 L1_N156 4.4022254443e+06
R_Conv_1_6_0_0_2_2_1 L0_N789 L1_N156 1.5358515901e+05
*
R_Conv_1_6_0_1_0_0_0 L0_N672 L1_N157 1.2123709737e+05
R_Conv_1_6_0_1_0_0_1 L0_N673 L1_N157 1.0849154640e+05
R_Conv_1_6_0_1_0_1_0 L0_N674 L1_N157 2.0480317885e+05
R_Conv_1_6_0_1_0_1_1 L0_N675 L1_N157 1.6641635952e+05
R_Conv_1_6_0_1_0_2_0 L0_N676 L1_N157 1.1683261279e+06
R_Conv_1_6_0_1_0_2_1 L0_N677 L1_N157 1.1602008983e+05
R_Conv_1_6_0_1_1_0_0 L0_N728 L1_N157 1.2296662853e+05
R_Conv_1_6_0_1_1_0_1 L0_N729 L1_N157 1.6882235068e+05
R_Conv_1_6_0_1_1_1_0 L0_N730 L1_N157 1.0472083211e+05
R_Conv_1_6_0_1_1_1_1 L0_N731 L1_N157 2.1167619859e+05
R_Conv_1_6_0_1_1_2_0 L0_N732 L1_N157 1.3518319025e+05
R_Conv_1_6_0_1_1_2_1 L0_N733 L1_N157 1.4280846670e+05
R_Conv_1_6_0_1_2_0_0 L0_N784 L1_N157 1.1620759255e+05
R_Conv_1_6_0_1_2_0_1 L0_N785 L1_N157 1.6895116802e+05
R_Conv_1_6_0_1_2_1_0 L0_N786 L1_N157 1.2455043512e+06
R_Conv_1_6_0_1_2_1_1 L0_N787 L1_N157 1.1694022847e+05
R_Conv_1_6_0_1_2_2_0 L0_N788 L1_N157 1.5663616684e+06
R_Conv_1_6_0_1_2_2_1 L0_N789 L1_N157 2.1466641264e+05
*
R_Conv_1_6_1_0_0_0_0 L0_N676 L1_N158 3.0927915375e+05
R_Conv_1_6_1_0_0_0_1 L0_N677 L1_N158 3.6154472179e+05
R_Conv_1_6_1_0_0_1_0 L0_N678 L1_N158 1.2307612303e+05
R_Conv_1_6_1_0_0_1_1 L0_N679 L1_N158 1.3361401953e+06
R_Conv_1_6_1_0_0_2_0 L0_N680 L1_N158 1.1771240850e+06
R_Conv_1_6_1_0_0_2_1 L0_N681 L1_N158 1.1947062568e+05
R_Conv_1_6_1_0_1_0_0 L0_N732 L1_N158 3.4555602430e+05
R_Conv_1_6_1_0_1_0_1 L0_N733 L1_N158 1.2140655673e+05
R_Conv_1_6_1_0_1_1_0 L0_N734 L1_N158 2.0024008865e+05
R_Conv_1_6_1_0_1_1_1 L0_N735 L1_N158 1.3019124074e+05
R_Conv_1_6_1_0_1_2_0 L0_N736 L1_N158 1.1085089352e+05
R_Conv_1_6_1_0_1_2_1 L0_N737 L1_N158 2.5251460583e+05
R_Conv_1_6_1_0_2_0_0 L0_N788 L1_N158 1.1040315248e+05
R_Conv_1_6_1_0_2_0_1 L0_N789 L1_N158 1.2105931856e+05
R_Conv_1_6_1_0_2_1_0 L0_N790 L1_N158 1.0186236681e+05
R_Conv_1_6_1_0_2_1_1 L0_N791 L1_N158 3.8798345399e+05
R_Conv_1_6_1_0_2_2_0 L0_N792 L1_N158 4.4022254443e+06
R_Conv_1_6_1_0_2_2_1 L0_N793 L1_N158 1.5358515901e+05
*
R_Conv_1_6_1_1_0_0_0 L0_N676 L1_N159 1.2123709737e+05
R_Conv_1_6_1_1_0_0_1 L0_N677 L1_N159 1.0849154640e+05
R_Conv_1_6_1_1_0_1_0 L0_N678 L1_N159 2.0480317885e+05
R_Conv_1_6_1_1_0_1_1 L0_N679 L1_N159 1.6641635952e+05
R_Conv_1_6_1_1_0_2_0 L0_N680 L1_N159 1.1683261279e+06
R_Conv_1_6_1_1_0_2_1 L0_N681 L1_N159 1.1602008983e+05
R_Conv_1_6_1_1_1_0_0 L0_N732 L1_N159 1.2296662853e+05
R_Conv_1_6_1_1_1_0_1 L0_N733 L1_N159 1.6882235068e+05
R_Conv_1_6_1_1_1_1_0 L0_N734 L1_N159 1.0472083211e+05
R_Conv_1_6_1_1_1_1_1 L0_N735 L1_N159 2.1167619859e+05
R_Conv_1_6_1_1_1_2_0 L0_N736 L1_N159 1.3518319025e+05
R_Conv_1_6_1_1_1_2_1 L0_N737 L1_N159 1.4280846670e+05
R_Conv_1_6_1_1_2_0_0 L0_N788 L1_N159 1.1620759255e+05
R_Conv_1_6_1_1_2_0_1 L0_N789 L1_N159 1.6895116802e+05
R_Conv_1_6_1_1_2_1_0 L0_N790 L1_N159 1.2455043512e+06
R_Conv_1_6_1_1_2_1_1 L0_N791 L1_N159 1.1694022847e+05
R_Conv_1_6_1_1_2_2_0 L0_N792 L1_N159 1.5663616684e+06
R_Conv_1_6_1_1_2_2_1 L0_N793 L1_N159 2.1466641264e+05
*
R_Conv_1_6_2_0_0_0_0 L0_N680 L1_N160 3.0927915375e+05
R_Conv_1_6_2_0_0_0_1 L0_N681 L1_N160 3.6154472179e+05
R_Conv_1_6_2_0_0_1_0 L0_N682 L1_N160 1.2307612303e+05
R_Conv_1_6_2_0_0_1_1 L0_N683 L1_N160 1.3361401953e+06
R_Conv_1_6_2_0_0_2_0 L0_N684 L1_N160 1.1771240850e+06
R_Conv_1_6_2_0_0_2_1 L0_N685 L1_N160 1.1947062568e+05
R_Conv_1_6_2_0_1_0_0 L0_N736 L1_N160 3.4555602430e+05
R_Conv_1_6_2_0_1_0_1 L0_N737 L1_N160 1.2140655673e+05
R_Conv_1_6_2_0_1_1_0 L0_N738 L1_N160 2.0024008865e+05
R_Conv_1_6_2_0_1_1_1 L0_N739 L1_N160 1.3019124074e+05
R_Conv_1_6_2_0_1_2_0 L0_N740 L1_N160 1.1085089352e+05
R_Conv_1_6_2_0_1_2_1 L0_N741 L1_N160 2.5251460583e+05
R_Conv_1_6_2_0_2_0_0 L0_N792 L1_N160 1.1040315248e+05
R_Conv_1_6_2_0_2_0_1 L0_N793 L1_N160 1.2105931856e+05
R_Conv_1_6_2_0_2_1_0 L0_N794 L1_N160 1.0186236681e+05
R_Conv_1_6_2_0_2_1_1 L0_N795 L1_N160 3.8798345399e+05
R_Conv_1_6_2_0_2_2_0 L0_N796 L1_N160 4.4022254443e+06
R_Conv_1_6_2_0_2_2_1 L0_N797 L1_N160 1.5358515901e+05
*
R_Conv_1_6_2_1_0_0_0 L0_N680 L1_N161 1.2123709737e+05
R_Conv_1_6_2_1_0_0_1 L0_N681 L1_N161 1.0849154640e+05
R_Conv_1_6_2_1_0_1_0 L0_N682 L1_N161 2.0480317885e+05
R_Conv_1_6_2_1_0_1_1 L0_N683 L1_N161 1.6641635952e+05
R_Conv_1_6_2_1_0_2_0 L0_N684 L1_N161 1.1683261279e+06
R_Conv_1_6_2_1_0_2_1 L0_N685 L1_N161 1.1602008983e+05
R_Conv_1_6_2_1_1_0_0 L0_N736 L1_N161 1.2296662853e+05
R_Conv_1_6_2_1_1_0_1 L0_N737 L1_N161 1.6882235068e+05
R_Conv_1_6_2_1_1_1_0 L0_N738 L1_N161 1.0472083211e+05
R_Conv_1_6_2_1_1_1_1 L0_N739 L1_N161 2.1167619859e+05
R_Conv_1_6_2_1_1_2_0 L0_N740 L1_N161 1.3518319025e+05
R_Conv_1_6_2_1_1_2_1 L0_N741 L1_N161 1.4280846670e+05
R_Conv_1_6_2_1_2_0_0 L0_N792 L1_N161 1.1620759255e+05
R_Conv_1_6_2_1_2_0_1 L0_N793 L1_N161 1.6895116802e+05
R_Conv_1_6_2_1_2_1_0 L0_N794 L1_N161 1.2455043512e+06
R_Conv_1_6_2_1_2_1_1 L0_N795 L1_N161 1.1694022847e+05
R_Conv_1_6_2_1_2_2_0 L0_N796 L1_N161 1.5663616684e+06
R_Conv_1_6_2_1_2_2_1 L0_N797 L1_N161 2.1466641264e+05
*
R_Conv_1_6_3_0_0_0_0 L0_N684 L1_N162 3.0927915375e+05
R_Conv_1_6_3_0_0_0_1 L0_N685 L1_N162 3.6154472179e+05
R_Conv_1_6_3_0_0_1_0 L0_N686 L1_N162 1.2307612303e+05
R_Conv_1_6_3_0_0_1_1 L0_N687 L1_N162 1.3361401953e+06
R_Conv_1_6_3_0_0_2_0 L0_N688 L1_N162 1.1771240850e+06
R_Conv_1_6_3_0_0_2_1 L0_N689 L1_N162 1.1947062568e+05
R_Conv_1_6_3_0_1_0_0 L0_N740 L1_N162 3.4555602430e+05
R_Conv_1_6_3_0_1_0_1 L0_N741 L1_N162 1.2140655673e+05
R_Conv_1_6_3_0_1_1_0 L0_N742 L1_N162 2.0024008865e+05
R_Conv_1_6_3_0_1_1_1 L0_N743 L1_N162 1.3019124074e+05
R_Conv_1_6_3_0_1_2_0 L0_N744 L1_N162 1.1085089352e+05
R_Conv_1_6_3_0_1_2_1 L0_N745 L1_N162 2.5251460583e+05
R_Conv_1_6_3_0_2_0_0 L0_N796 L1_N162 1.1040315248e+05
R_Conv_1_6_3_0_2_0_1 L0_N797 L1_N162 1.2105931856e+05
R_Conv_1_6_3_0_2_1_0 L0_N798 L1_N162 1.0186236681e+05
R_Conv_1_6_3_0_2_1_1 L0_N799 L1_N162 3.8798345399e+05
R_Conv_1_6_3_0_2_2_0 L0_N800 L1_N162 4.4022254443e+06
R_Conv_1_6_3_0_2_2_1 L0_N801 L1_N162 1.5358515901e+05
*
R_Conv_1_6_3_1_0_0_0 L0_N684 L1_N163 1.2123709737e+05
R_Conv_1_6_3_1_0_0_1 L0_N685 L1_N163 1.0849154640e+05
R_Conv_1_6_3_1_0_1_0 L0_N686 L1_N163 2.0480317885e+05
R_Conv_1_6_3_1_0_1_1 L0_N687 L1_N163 1.6641635952e+05
R_Conv_1_6_3_1_0_2_0 L0_N688 L1_N163 1.1683261279e+06
R_Conv_1_6_3_1_0_2_1 L0_N689 L1_N163 1.1602008983e+05
R_Conv_1_6_3_1_1_0_0 L0_N740 L1_N163 1.2296662853e+05
R_Conv_1_6_3_1_1_0_1 L0_N741 L1_N163 1.6882235068e+05
R_Conv_1_6_3_1_1_1_0 L0_N742 L1_N163 1.0472083211e+05
R_Conv_1_6_3_1_1_1_1 L0_N743 L1_N163 2.1167619859e+05
R_Conv_1_6_3_1_1_2_0 L0_N744 L1_N163 1.3518319025e+05
R_Conv_1_6_3_1_1_2_1 L0_N745 L1_N163 1.4280846670e+05
R_Conv_1_6_3_1_2_0_0 L0_N796 L1_N163 1.1620759255e+05
R_Conv_1_6_3_1_2_0_1 L0_N797 L1_N163 1.6895116802e+05
R_Conv_1_6_3_1_2_1_0 L0_N798 L1_N163 1.2455043512e+06
R_Conv_1_6_3_1_2_1_1 L0_N799 L1_N163 1.1694022847e+05
R_Conv_1_6_3_1_2_2_0 L0_N800 L1_N163 1.5663616684e+06
R_Conv_1_6_3_1_2_2_1 L0_N801 L1_N163 2.1466641264e+05
*
R_Conv_1_6_4_0_0_0_0 L0_N688 L1_N164 3.0927915375e+05
R_Conv_1_6_4_0_0_0_1 L0_N689 L1_N164 3.6154472179e+05
R_Conv_1_6_4_0_0_1_0 L0_N690 L1_N164 1.2307612303e+05
R_Conv_1_6_4_0_0_1_1 L0_N691 L1_N164 1.3361401953e+06
R_Conv_1_6_4_0_0_2_0 L0_N692 L1_N164 1.1771240850e+06
R_Conv_1_6_4_0_0_2_1 L0_N693 L1_N164 1.1947062568e+05
R_Conv_1_6_4_0_1_0_0 L0_N744 L1_N164 3.4555602430e+05
R_Conv_1_6_4_0_1_0_1 L0_N745 L1_N164 1.2140655673e+05
R_Conv_1_6_4_0_1_1_0 L0_N746 L1_N164 2.0024008865e+05
R_Conv_1_6_4_0_1_1_1 L0_N747 L1_N164 1.3019124074e+05
R_Conv_1_6_4_0_1_2_0 L0_N748 L1_N164 1.1085089352e+05
R_Conv_1_6_4_0_1_2_1 L0_N749 L1_N164 2.5251460583e+05
R_Conv_1_6_4_0_2_0_0 L0_N800 L1_N164 1.1040315248e+05
R_Conv_1_6_4_0_2_0_1 L0_N801 L1_N164 1.2105931856e+05
R_Conv_1_6_4_0_2_1_0 L0_N802 L1_N164 1.0186236681e+05
R_Conv_1_6_4_0_2_1_1 L0_N803 L1_N164 3.8798345399e+05
R_Conv_1_6_4_0_2_2_0 L0_N804 L1_N164 4.4022254443e+06
R_Conv_1_6_4_0_2_2_1 L0_N805 L1_N164 1.5358515901e+05
*
R_Conv_1_6_4_1_0_0_0 L0_N688 L1_N165 1.2123709737e+05
R_Conv_1_6_4_1_0_0_1 L0_N689 L1_N165 1.0849154640e+05
R_Conv_1_6_4_1_0_1_0 L0_N690 L1_N165 2.0480317885e+05
R_Conv_1_6_4_1_0_1_1 L0_N691 L1_N165 1.6641635952e+05
R_Conv_1_6_4_1_0_2_0 L0_N692 L1_N165 1.1683261279e+06
R_Conv_1_6_4_1_0_2_1 L0_N693 L1_N165 1.1602008983e+05
R_Conv_1_6_4_1_1_0_0 L0_N744 L1_N165 1.2296662853e+05
R_Conv_1_6_4_1_1_0_1 L0_N745 L1_N165 1.6882235068e+05
R_Conv_1_6_4_1_1_1_0 L0_N746 L1_N165 1.0472083211e+05
R_Conv_1_6_4_1_1_1_1 L0_N747 L1_N165 2.1167619859e+05
R_Conv_1_6_4_1_1_2_0 L0_N748 L1_N165 1.3518319025e+05
R_Conv_1_6_4_1_1_2_1 L0_N749 L1_N165 1.4280846670e+05
R_Conv_1_6_4_1_2_0_0 L0_N800 L1_N165 1.1620759255e+05
R_Conv_1_6_4_1_2_0_1 L0_N801 L1_N165 1.6895116802e+05
R_Conv_1_6_4_1_2_1_0 L0_N802 L1_N165 1.2455043512e+06
R_Conv_1_6_4_1_2_1_1 L0_N803 L1_N165 1.1694022847e+05
R_Conv_1_6_4_1_2_2_0 L0_N804 L1_N165 1.5663616684e+06
R_Conv_1_6_4_1_2_2_1 L0_N805 L1_N165 2.1466641264e+05
*
R_Conv_1_6_5_0_0_0_0 L0_N692 L1_N166 3.0927915375e+05
R_Conv_1_6_5_0_0_0_1 L0_N693 L1_N166 3.6154472179e+05
R_Conv_1_6_5_0_0_1_0 L0_N694 L1_N166 1.2307612303e+05
R_Conv_1_6_5_0_0_1_1 L0_N695 L1_N166 1.3361401953e+06
R_Conv_1_6_5_0_0_2_0 L0_N696 L1_N166 1.1771240850e+06
R_Conv_1_6_5_0_0_2_1 L0_N697 L1_N166 1.1947062568e+05
R_Conv_1_6_5_0_1_0_0 L0_N748 L1_N166 3.4555602430e+05
R_Conv_1_6_5_0_1_0_1 L0_N749 L1_N166 1.2140655673e+05
R_Conv_1_6_5_0_1_1_0 L0_N750 L1_N166 2.0024008865e+05
R_Conv_1_6_5_0_1_1_1 L0_N751 L1_N166 1.3019124074e+05
R_Conv_1_6_5_0_1_2_0 L0_N752 L1_N166 1.1085089352e+05
R_Conv_1_6_5_0_1_2_1 L0_N753 L1_N166 2.5251460583e+05
R_Conv_1_6_5_0_2_0_0 L0_N804 L1_N166 1.1040315248e+05
R_Conv_1_6_5_0_2_0_1 L0_N805 L1_N166 1.2105931856e+05
R_Conv_1_6_5_0_2_1_0 L0_N806 L1_N166 1.0186236681e+05
R_Conv_1_6_5_0_2_1_1 L0_N807 L1_N166 3.8798345399e+05
R_Conv_1_6_5_0_2_2_0 L0_N808 L1_N166 4.4022254443e+06
R_Conv_1_6_5_0_2_2_1 L0_N809 L1_N166 1.5358515901e+05
*
R_Conv_1_6_5_1_0_0_0 L0_N692 L1_N167 1.2123709737e+05
R_Conv_1_6_5_1_0_0_1 L0_N693 L1_N167 1.0849154640e+05
R_Conv_1_6_5_1_0_1_0 L0_N694 L1_N167 2.0480317885e+05
R_Conv_1_6_5_1_0_1_1 L0_N695 L1_N167 1.6641635952e+05
R_Conv_1_6_5_1_0_2_0 L0_N696 L1_N167 1.1683261279e+06
R_Conv_1_6_5_1_0_2_1 L0_N697 L1_N167 1.1602008983e+05
R_Conv_1_6_5_1_1_0_0 L0_N748 L1_N167 1.2296662853e+05
R_Conv_1_6_5_1_1_0_1 L0_N749 L1_N167 1.6882235068e+05
R_Conv_1_6_5_1_1_1_0 L0_N750 L1_N167 1.0472083211e+05
R_Conv_1_6_5_1_1_1_1 L0_N751 L1_N167 2.1167619859e+05
R_Conv_1_6_5_1_1_2_0 L0_N752 L1_N167 1.3518319025e+05
R_Conv_1_6_5_1_1_2_1 L0_N753 L1_N167 1.4280846670e+05
R_Conv_1_6_5_1_2_0_0 L0_N804 L1_N167 1.1620759255e+05
R_Conv_1_6_5_1_2_0_1 L0_N805 L1_N167 1.6895116802e+05
R_Conv_1_6_5_1_2_1_0 L0_N806 L1_N167 1.2455043512e+06
R_Conv_1_6_5_1_2_1_1 L0_N807 L1_N167 1.1694022847e+05
R_Conv_1_6_5_1_2_2_0 L0_N808 L1_N167 1.5663616684e+06
R_Conv_1_6_5_1_2_2_1 L0_N809 L1_N167 2.1466641264e+05
*
R_Conv_1_6_6_0_0_0_0 L0_N696 L1_N168 3.0927915375e+05
R_Conv_1_6_6_0_0_0_1 L0_N697 L1_N168 3.6154472179e+05
R_Conv_1_6_6_0_0_1_0 L0_N698 L1_N168 1.2307612303e+05
R_Conv_1_6_6_0_0_1_1 L0_N699 L1_N168 1.3361401953e+06
R_Conv_1_6_6_0_0_2_0 L0_N700 L1_N168 1.1771240850e+06
R_Conv_1_6_6_0_0_2_1 L0_N701 L1_N168 1.1947062568e+05
R_Conv_1_6_6_0_1_0_0 L0_N752 L1_N168 3.4555602430e+05
R_Conv_1_6_6_0_1_0_1 L0_N753 L1_N168 1.2140655673e+05
R_Conv_1_6_6_0_1_1_0 L0_N754 L1_N168 2.0024008865e+05
R_Conv_1_6_6_0_1_1_1 L0_N755 L1_N168 1.3019124074e+05
R_Conv_1_6_6_0_1_2_0 L0_N756 L1_N168 1.1085089352e+05
R_Conv_1_6_6_0_1_2_1 L0_N757 L1_N168 2.5251460583e+05
R_Conv_1_6_6_0_2_0_0 L0_N808 L1_N168 1.1040315248e+05
R_Conv_1_6_6_0_2_0_1 L0_N809 L1_N168 1.2105931856e+05
R_Conv_1_6_6_0_2_1_0 L0_N810 L1_N168 1.0186236681e+05
R_Conv_1_6_6_0_2_1_1 L0_N811 L1_N168 3.8798345399e+05
R_Conv_1_6_6_0_2_2_0 L0_N812 L1_N168 4.4022254443e+06
R_Conv_1_6_6_0_2_2_1 L0_N813 L1_N168 1.5358515901e+05
*
R_Conv_1_6_6_1_0_0_0 L0_N696 L1_N169 1.2123709737e+05
R_Conv_1_6_6_1_0_0_1 L0_N697 L1_N169 1.0849154640e+05
R_Conv_1_6_6_1_0_1_0 L0_N698 L1_N169 2.0480317885e+05
R_Conv_1_6_6_1_0_1_1 L0_N699 L1_N169 1.6641635952e+05
R_Conv_1_6_6_1_0_2_0 L0_N700 L1_N169 1.1683261279e+06
R_Conv_1_6_6_1_0_2_1 L0_N701 L1_N169 1.1602008983e+05
R_Conv_1_6_6_1_1_0_0 L0_N752 L1_N169 1.2296662853e+05
R_Conv_1_6_6_1_1_0_1 L0_N753 L1_N169 1.6882235068e+05
R_Conv_1_6_6_1_1_1_0 L0_N754 L1_N169 1.0472083211e+05
R_Conv_1_6_6_1_1_1_1 L0_N755 L1_N169 2.1167619859e+05
R_Conv_1_6_6_1_1_2_0 L0_N756 L1_N169 1.3518319025e+05
R_Conv_1_6_6_1_1_2_1 L0_N757 L1_N169 1.4280846670e+05
R_Conv_1_6_6_1_2_0_0 L0_N808 L1_N169 1.1620759255e+05
R_Conv_1_6_6_1_2_0_1 L0_N809 L1_N169 1.6895116802e+05
R_Conv_1_6_6_1_2_1_0 L0_N810 L1_N169 1.2455043512e+06
R_Conv_1_6_6_1_2_1_1 L0_N811 L1_N169 1.1694022847e+05
R_Conv_1_6_6_1_2_2_0 L0_N812 L1_N169 1.5663616684e+06
R_Conv_1_6_6_1_2_2_1 L0_N813 L1_N169 2.1466641264e+05
*
R_Conv_1_6_7_0_0_0_0 L0_N700 L1_N170 3.0927915375e+05
R_Conv_1_6_7_0_0_0_1 L0_N701 L1_N170 3.6154472179e+05
R_Conv_1_6_7_0_0_1_0 L0_N702 L1_N170 1.2307612303e+05
R_Conv_1_6_7_0_0_1_1 L0_N703 L1_N170 1.3361401953e+06
R_Conv_1_6_7_0_0_2_0 L0_N704 L1_N170 1.1771240850e+06
R_Conv_1_6_7_0_0_2_1 L0_N705 L1_N170 1.1947062568e+05
R_Conv_1_6_7_0_1_0_0 L0_N756 L1_N170 3.4555602430e+05
R_Conv_1_6_7_0_1_0_1 L0_N757 L1_N170 1.2140655673e+05
R_Conv_1_6_7_0_1_1_0 L0_N758 L1_N170 2.0024008865e+05
R_Conv_1_6_7_0_1_1_1 L0_N759 L1_N170 1.3019124074e+05
R_Conv_1_6_7_0_1_2_0 L0_N760 L1_N170 1.1085089352e+05
R_Conv_1_6_7_0_1_2_1 L0_N761 L1_N170 2.5251460583e+05
R_Conv_1_6_7_0_2_0_0 L0_N812 L1_N170 1.1040315248e+05
R_Conv_1_6_7_0_2_0_1 L0_N813 L1_N170 1.2105931856e+05
R_Conv_1_6_7_0_2_1_0 L0_N814 L1_N170 1.0186236681e+05
R_Conv_1_6_7_0_2_1_1 L0_N815 L1_N170 3.8798345399e+05
R_Conv_1_6_7_0_2_2_0 L0_N816 L1_N170 4.4022254443e+06
R_Conv_1_6_7_0_2_2_1 L0_N817 L1_N170 1.5358515901e+05
*
R_Conv_1_6_7_1_0_0_0 L0_N700 L1_N171 1.2123709737e+05
R_Conv_1_6_7_1_0_0_1 L0_N701 L1_N171 1.0849154640e+05
R_Conv_1_6_7_1_0_1_0 L0_N702 L1_N171 2.0480317885e+05
R_Conv_1_6_7_1_0_1_1 L0_N703 L1_N171 1.6641635952e+05
R_Conv_1_6_7_1_0_2_0 L0_N704 L1_N171 1.1683261279e+06
R_Conv_1_6_7_1_0_2_1 L0_N705 L1_N171 1.1602008983e+05
R_Conv_1_6_7_1_1_0_0 L0_N756 L1_N171 1.2296662853e+05
R_Conv_1_6_7_1_1_0_1 L0_N757 L1_N171 1.6882235068e+05
R_Conv_1_6_7_1_1_1_0 L0_N758 L1_N171 1.0472083211e+05
R_Conv_1_6_7_1_1_1_1 L0_N759 L1_N171 2.1167619859e+05
R_Conv_1_6_7_1_1_2_0 L0_N760 L1_N171 1.3518319025e+05
R_Conv_1_6_7_1_1_2_1 L0_N761 L1_N171 1.4280846670e+05
R_Conv_1_6_7_1_2_0_0 L0_N812 L1_N171 1.1620759255e+05
R_Conv_1_6_7_1_2_0_1 L0_N813 L1_N171 1.6895116802e+05
R_Conv_1_6_7_1_2_1_0 L0_N814 L1_N171 1.2455043512e+06
R_Conv_1_6_7_1_2_1_1 L0_N815 L1_N171 1.1694022847e+05
R_Conv_1_6_7_1_2_2_0 L0_N816 L1_N171 1.5663616684e+06
R_Conv_1_6_7_1_2_2_1 L0_N817 L1_N171 2.1466641264e+05
*
R_Conv_1_6_8_0_0_0_0 L0_N704 L1_N172 3.0927915375e+05
R_Conv_1_6_8_0_0_0_1 L0_N705 L1_N172 3.6154472179e+05
R_Conv_1_6_8_0_0_1_0 L0_N706 L1_N172 1.2307612303e+05
R_Conv_1_6_8_0_0_1_1 L0_N707 L1_N172 1.3361401953e+06
R_Conv_1_6_8_0_0_2_0 L0_N708 L1_N172 1.1771240850e+06
R_Conv_1_6_8_0_0_2_1 L0_N709 L1_N172 1.1947062568e+05
R_Conv_1_6_8_0_1_0_0 L0_N760 L1_N172 3.4555602430e+05
R_Conv_1_6_8_0_1_0_1 L0_N761 L1_N172 1.2140655673e+05
R_Conv_1_6_8_0_1_1_0 L0_N762 L1_N172 2.0024008865e+05
R_Conv_1_6_8_0_1_1_1 L0_N763 L1_N172 1.3019124074e+05
R_Conv_1_6_8_0_1_2_0 L0_N764 L1_N172 1.1085089352e+05
R_Conv_1_6_8_0_1_2_1 L0_N765 L1_N172 2.5251460583e+05
R_Conv_1_6_8_0_2_0_0 L0_N816 L1_N172 1.1040315248e+05
R_Conv_1_6_8_0_2_0_1 L0_N817 L1_N172 1.2105931856e+05
R_Conv_1_6_8_0_2_1_0 L0_N818 L1_N172 1.0186236681e+05
R_Conv_1_6_8_0_2_1_1 L0_N819 L1_N172 3.8798345399e+05
R_Conv_1_6_8_0_2_2_0 L0_N820 L1_N172 4.4022254443e+06
R_Conv_1_6_8_0_2_2_1 L0_N821 L1_N172 1.5358515901e+05
*
R_Conv_1_6_8_1_0_0_0 L0_N704 L1_N173 1.2123709737e+05
R_Conv_1_6_8_1_0_0_1 L0_N705 L1_N173 1.0849154640e+05
R_Conv_1_6_8_1_0_1_0 L0_N706 L1_N173 2.0480317885e+05
R_Conv_1_6_8_1_0_1_1 L0_N707 L1_N173 1.6641635952e+05
R_Conv_1_6_8_1_0_2_0 L0_N708 L1_N173 1.1683261279e+06
R_Conv_1_6_8_1_0_2_1 L0_N709 L1_N173 1.1602008983e+05
R_Conv_1_6_8_1_1_0_0 L0_N760 L1_N173 1.2296662853e+05
R_Conv_1_6_8_1_1_0_1 L0_N761 L1_N173 1.6882235068e+05
R_Conv_1_6_8_1_1_1_0 L0_N762 L1_N173 1.0472083211e+05
R_Conv_1_6_8_1_1_1_1 L0_N763 L1_N173 2.1167619859e+05
R_Conv_1_6_8_1_1_2_0 L0_N764 L1_N173 1.3518319025e+05
R_Conv_1_6_8_1_1_2_1 L0_N765 L1_N173 1.4280846670e+05
R_Conv_1_6_8_1_2_0_0 L0_N816 L1_N173 1.1620759255e+05
R_Conv_1_6_8_1_2_0_1 L0_N817 L1_N173 1.6895116802e+05
R_Conv_1_6_8_1_2_1_0 L0_N818 L1_N173 1.2455043512e+06
R_Conv_1_6_8_1_2_1_1 L0_N819 L1_N173 1.1694022847e+05
R_Conv_1_6_8_1_2_2_0 L0_N820 L1_N173 1.5663616684e+06
R_Conv_1_6_8_1_2_2_1 L0_N821 L1_N173 2.1466641264e+05
*
R_Conv_1_6_9_0_0_0_0 L0_N708 L1_N174 3.0927915375e+05
R_Conv_1_6_9_0_0_0_1 L0_N709 L1_N174 3.6154472179e+05
R_Conv_1_6_9_0_0_1_0 L0_N710 L1_N174 1.2307612303e+05
R_Conv_1_6_9_0_0_1_1 L0_N711 L1_N174 1.3361401953e+06
R_Conv_1_6_9_0_0_2_0 L0_N712 L1_N174 1.1771240850e+06
R_Conv_1_6_9_0_0_2_1 L0_N713 L1_N174 1.1947062568e+05
R_Conv_1_6_9_0_1_0_0 L0_N764 L1_N174 3.4555602430e+05
R_Conv_1_6_9_0_1_0_1 L0_N765 L1_N174 1.2140655673e+05
R_Conv_1_6_9_0_1_1_0 L0_N766 L1_N174 2.0024008865e+05
R_Conv_1_6_9_0_1_1_1 L0_N767 L1_N174 1.3019124074e+05
R_Conv_1_6_9_0_1_2_0 L0_N768 L1_N174 1.1085089352e+05
R_Conv_1_6_9_0_1_2_1 L0_N769 L1_N174 2.5251460583e+05
R_Conv_1_6_9_0_2_0_0 L0_N820 L1_N174 1.1040315248e+05
R_Conv_1_6_9_0_2_0_1 L0_N821 L1_N174 1.2105931856e+05
R_Conv_1_6_9_0_2_1_0 L0_N822 L1_N174 1.0186236681e+05
R_Conv_1_6_9_0_2_1_1 L0_N823 L1_N174 3.8798345399e+05
R_Conv_1_6_9_0_2_2_0 L0_N824 L1_N174 4.4022254443e+06
R_Conv_1_6_9_0_2_2_1 L0_N825 L1_N174 1.5358515901e+05
*
R_Conv_1_6_9_1_0_0_0 L0_N708 L1_N175 1.2123709737e+05
R_Conv_1_6_9_1_0_0_1 L0_N709 L1_N175 1.0849154640e+05
R_Conv_1_6_9_1_0_1_0 L0_N710 L1_N175 2.0480317885e+05
R_Conv_1_6_9_1_0_1_1 L0_N711 L1_N175 1.6641635952e+05
R_Conv_1_6_9_1_0_2_0 L0_N712 L1_N175 1.1683261279e+06
R_Conv_1_6_9_1_0_2_1 L0_N713 L1_N175 1.1602008983e+05
R_Conv_1_6_9_1_1_0_0 L0_N764 L1_N175 1.2296662853e+05
R_Conv_1_6_9_1_1_0_1 L0_N765 L1_N175 1.6882235068e+05
R_Conv_1_6_9_1_1_1_0 L0_N766 L1_N175 1.0472083211e+05
R_Conv_1_6_9_1_1_1_1 L0_N767 L1_N175 2.1167619859e+05
R_Conv_1_6_9_1_1_2_0 L0_N768 L1_N175 1.3518319025e+05
R_Conv_1_6_9_1_1_2_1 L0_N769 L1_N175 1.4280846670e+05
R_Conv_1_6_9_1_2_0_0 L0_N820 L1_N175 1.1620759255e+05
R_Conv_1_6_9_1_2_0_1 L0_N821 L1_N175 1.6895116802e+05
R_Conv_1_6_9_1_2_1_0 L0_N822 L1_N175 1.2455043512e+06
R_Conv_1_6_9_1_2_1_1 L0_N823 L1_N175 1.1694022847e+05
R_Conv_1_6_9_1_2_2_0 L0_N824 L1_N175 1.5663616684e+06
R_Conv_1_6_9_1_2_2_1 L0_N825 L1_N175 2.1466641264e+05
*
R_Conv_1_6_10_0_0_0_0 L0_N712 L1_N176 3.0927915375e+05
R_Conv_1_6_10_0_0_0_1 L0_N713 L1_N176 3.6154472179e+05
R_Conv_1_6_10_0_0_1_0 L0_N714 L1_N176 1.2307612303e+05
R_Conv_1_6_10_0_0_1_1 L0_N715 L1_N176 1.3361401953e+06
R_Conv_1_6_10_0_0_2_0 L0_N716 L1_N176 1.1771240850e+06
R_Conv_1_6_10_0_0_2_1 L0_N717 L1_N176 1.1947062568e+05
R_Conv_1_6_10_0_1_0_0 L0_N768 L1_N176 3.4555602430e+05
R_Conv_1_6_10_0_1_0_1 L0_N769 L1_N176 1.2140655673e+05
R_Conv_1_6_10_0_1_1_0 L0_N770 L1_N176 2.0024008865e+05
R_Conv_1_6_10_0_1_1_1 L0_N771 L1_N176 1.3019124074e+05
R_Conv_1_6_10_0_1_2_0 L0_N772 L1_N176 1.1085089352e+05
R_Conv_1_6_10_0_1_2_1 L0_N773 L1_N176 2.5251460583e+05
R_Conv_1_6_10_0_2_0_0 L0_N824 L1_N176 1.1040315248e+05
R_Conv_1_6_10_0_2_0_1 L0_N825 L1_N176 1.2105931856e+05
R_Conv_1_6_10_0_2_1_0 L0_N826 L1_N176 1.0186236681e+05
R_Conv_1_6_10_0_2_1_1 L0_N827 L1_N176 3.8798345399e+05
R_Conv_1_6_10_0_2_2_0 L0_N828 L1_N176 4.4022254443e+06
R_Conv_1_6_10_0_2_2_1 L0_N829 L1_N176 1.5358515901e+05
*
R_Conv_1_6_10_1_0_0_0 L0_N712 L1_N177 1.2123709737e+05
R_Conv_1_6_10_1_0_0_1 L0_N713 L1_N177 1.0849154640e+05
R_Conv_1_6_10_1_0_1_0 L0_N714 L1_N177 2.0480317885e+05
R_Conv_1_6_10_1_0_1_1 L0_N715 L1_N177 1.6641635952e+05
R_Conv_1_6_10_1_0_2_0 L0_N716 L1_N177 1.1683261279e+06
R_Conv_1_6_10_1_0_2_1 L0_N717 L1_N177 1.1602008983e+05
R_Conv_1_6_10_1_1_0_0 L0_N768 L1_N177 1.2296662853e+05
R_Conv_1_6_10_1_1_0_1 L0_N769 L1_N177 1.6882235068e+05
R_Conv_1_6_10_1_1_1_0 L0_N770 L1_N177 1.0472083211e+05
R_Conv_1_6_10_1_1_1_1 L0_N771 L1_N177 2.1167619859e+05
R_Conv_1_6_10_1_1_2_0 L0_N772 L1_N177 1.3518319025e+05
R_Conv_1_6_10_1_1_2_1 L0_N773 L1_N177 1.4280846670e+05
R_Conv_1_6_10_1_2_0_0 L0_N824 L1_N177 1.1620759255e+05
R_Conv_1_6_10_1_2_0_1 L0_N825 L1_N177 1.6895116802e+05
R_Conv_1_6_10_1_2_1_0 L0_N826 L1_N177 1.2455043512e+06
R_Conv_1_6_10_1_2_1_1 L0_N827 L1_N177 1.1694022847e+05
R_Conv_1_6_10_1_2_2_0 L0_N828 L1_N177 1.5663616684e+06
R_Conv_1_6_10_1_2_2_1 L0_N829 L1_N177 2.1466641264e+05
*
R_Conv_1_6_11_0_0_0_0 L0_N716 L1_N178 3.0927915375e+05
R_Conv_1_6_11_0_0_0_1 L0_N717 L1_N178 3.6154472179e+05
R_Conv_1_6_11_0_0_1_0 L0_N718 L1_N178 1.2307612303e+05
R_Conv_1_6_11_0_0_1_1 L0_N719 L1_N178 1.3361401953e+06
R_Conv_1_6_11_0_0_2_0 L0_N720 L1_N178 1.1771240850e+06
R_Conv_1_6_11_0_0_2_1 L0_N721 L1_N178 1.1947062568e+05
R_Conv_1_6_11_0_1_0_0 L0_N772 L1_N178 3.4555602430e+05
R_Conv_1_6_11_0_1_0_1 L0_N773 L1_N178 1.2140655673e+05
R_Conv_1_6_11_0_1_1_0 L0_N774 L1_N178 2.0024008865e+05
R_Conv_1_6_11_0_1_1_1 L0_N775 L1_N178 1.3019124074e+05
R_Conv_1_6_11_0_1_2_0 L0_N776 L1_N178 1.1085089352e+05
R_Conv_1_6_11_0_1_2_1 L0_N777 L1_N178 2.5251460583e+05
R_Conv_1_6_11_0_2_0_0 L0_N828 L1_N178 1.1040315248e+05
R_Conv_1_6_11_0_2_0_1 L0_N829 L1_N178 1.2105931856e+05
R_Conv_1_6_11_0_2_1_0 L0_N830 L1_N178 1.0186236681e+05
R_Conv_1_6_11_0_2_1_1 L0_N831 L1_N178 3.8798345399e+05
R_Conv_1_6_11_0_2_2_0 L0_N832 L1_N178 4.4022254443e+06
R_Conv_1_6_11_0_2_2_1 L0_N833 L1_N178 1.5358515901e+05
*
R_Conv_1_6_11_1_0_0_0 L0_N716 L1_N179 1.2123709737e+05
R_Conv_1_6_11_1_0_0_1 L0_N717 L1_N179 1.0849154640e+05
R_Conv_1_6_11_1_0_1_0 L0_N718 L1_N179 2.0480317885e+05
R_Conv_1_6_11_1_0_1_1 L0_N719 L1_N179 1.6641635952e+05
R_Conv_1_6_11_1_0_2_0 L0_N720 L1_N179 1.1683261279e+06
R_Conv_1_6_11_1_0_2_1 L0_N721 L1_N179 1.1602008983e+05
R_Conv_1_6_11_1_1_0_0 L0_N772 L1_N179 1.2296662853e+05
R_Conv_1_6_11_1_1_0_1 L0_N773 L1_N179 1.6882235068e+05
R_Conv_1_6_11_1_1_1_0 L0_N774 L1_N179 1.0472083211e+05
R_Conv_1_6_11_1_1_1_1 L0_N775 L1_N179 2.1167619859e+05
R_Conv_1_6_11_1_1_2_0 L0_N776 L1_N179 1.3518319025e+05
R_Conv_1_6_11_1_1_2_1 L0_N777 L1_N179 1.4280846670e+05
R_Conv_1_6_11_1_2_0_0 L0_N828 L1_N179 1.1620759255e+05
R_Conv_1_6_11_1_2_0_1 L0_N829 L1_N179 1.6895116802e+05
R_Conv_1_6_11_1_2_1_0 L0_N830 L1_N179 1.2455043512e+06
R_Conv_1_6_11_1_2_1_1 L0_N831 L1_N179 1.1694022847e+05
R_Conv_1_6_11_1_2_2_0 L0_N832 L1_N179 1.5663616684e+06
R_Conv_1_6_11_1_2_2_1 L0_N833 L1_N179 2.1466641264e+05
*
R_Conv_1_6_12_0_0_0_0 L0_N720 L1_N180 3.0927915375e+05
R_Conv_1_6_12_0_0_0_1 L0_N721 L1_N180 3.6154472179e+05
R_Conv_1_6_12_0_0_1_0 L0_N722 L1_N180 1.2307612303e+05
R_Conv_1_6_12_0_0_1_1 L0_N723 L1_N180 1.3361401953e+06
R_Conv_1_6_12_0_0_2_0 L0_N724 L1_N180 1.1771240850e+06
R_Conv_1_6_12_0_0_2_1 L0_N725 L1_N180 1.1947062568e+05
R_Conv_1_6_12_0_1_0_0 L0_N776 L1_N180 3.4555602430e+05
R_Conv_1_6_12_0_1_0_1 L0_N777 L1_N180 1.2140655673e+05
R_Conv_1_6_12_0_1_1_0 L0_N778 L1_N180 2.0024008865e+05
R_Conv_1_6_12_0_1_1_1 L0_N779 L1_N180 1.3019124074e+05
R_Conv_1_6_12_0_1_2_0 L0_N780 L1_N180 1.1085089352e+05
R_Conv_1_6_12_0_1_2_1 L0_N781 L1_N180 2.5251460583e+05
R_Conv_1_6_12_0_2_0_0 L0_N832 L1_N180 1.1040315248e+05
R_Conv_1_6_12_0_2_0_1 L0_N833 L1_N180 1.2105931856e+05
R_Conv_1_6_12_0_2_1_0 L0_N834 L1_N180 1.0186236681e+05
R_Conv_1_6_12_0_2_1_1 L0_N835 L1_N180 3.8798345399e+05
R_Conv_1_6_12_0_2_2_0 L0_N836 L1_N180 4.4022254443e+06
R_Conv_1_6_12_0_2_2_1 L0_N837 L1_N180 1.5358515901e+05
*
R_Conv_1_6_12_1_0_0_0 L0_N720 L1_N181 1.2123709737e+05
R_Conv_1_6_12_1_0_0_1 L0_N721 L1_N181 1.0849154640e+05
R_Conv_1_6_12_1_0_1_0 L0_N722 L1_N181 2.0480317885e+05
R_Conv_1_6_12_1_0_1_1 L0_N723 L1_N181 1.6641635952e+05
R_Conv_1_6_12_1_0_2_0 L0_N724 L1_N181 1.1683261279e+06
R_Conv_1_6_12_1_0_2_1 L0_N725 L1_N181 1.1602008983e+05
R_Conv_1_6_12_1_1_0_0 L0_N776 L1_N181 1.2296662853e+05
R_Conv_1_6_12_1_1_0_1 L0_N777 L1_N181 1.6882235068e+05
R_Conv_1_6_12_1_1_1_0 L0_N778 L1_N181 1.0472083211e+05
R_Conv_1_6_12_1_1_1_1 L0_N779 L1_N181 2.1167619859e+05
R_Conv_1_6_12_1_1_2_0 L0_N780 L1_N181 1.3518319025e+05
R_Conv_1_6_12_1_1_2_1 L0_N781 L1_N181 1.4280846670e+05
R_Conv_1_6_12_1_2_0_0 L0_N832 L1_N181 1.1620759255e+05
R_Conv_1_6_12_1_2_0_1 L0_N833 L1_N181 1.6895116802e+05
R_Conv_1_6_12_1_2_1_0 L0_N834 L1_N181 1.2455043512e+06
R_Conv_1_6_12_1_2_1_1 L0_N835 L1_N181 1.1694022847e+05
R_Conv_1_6_12_1_2_2_0 L0_N836 L1_N181 1.5663616684e+06
R_Conv_1_6_12_1_2_2_1 L0_N837 L1_N181 2.1466641264e+05
*
R_Conv_1_7_0_0_0_0_0 L0_N784 L1_N182 3.0927915375e+05
R_Conv_1_7_0_0_0_0_1 L0_N785 L1_N182 3.6154472179e+05
R_Conv_1_7_0_0_0_1_0 L0_N786 L1_N182 1.2307612303e+05
R_Conv_1_7_0_0_0_1_1 L0_N787 L1_N182 1.3361401953e+06
R_Conv_1_7_0_0_0_2_0 L0_N788 L1_N182 1.1771240850e+06
R_Conv_1_7_0_0_0_2_1 L0_N789 L1_N182 1.1947062568e+05
R_Conv_1_7_0_0_1_0_0 L0_N840 L1_N182 3.4555602430e+05
R_Conv_1_7_0_0_1_0_1 L0_N841 L1_N182 1.2140655673e+05
R_Conv_1_7_0_0_1_1_0 L0_N842 L1_N182 2.0024008865e+05
R_Conv_1_7_0_0_1_1_1 L0_N843 L1_N182 1.3019124074e+05
R_Conv_1_7_0_0_1_2_0 L0_N844 L1_N182 1.1085089352e+05
R_Conv_1_7_0_0_1_2_1 L0_N845 L1_N182 2.5251460583e+05
R_Conv_1_7_0_0_2_0_0 L0_N896 L1_N182 1.1040315248e+05
R_Conv_1_7_0_0_2_0_1 L0_N897 L1_N182 1.2105931856e+05
R_Conv_1_7_0_0_2_1_0 L0_N898 L1_N182 1.0186236681e+05
R_Conv_1_7_0_0_2_1_1 L0_N899 L1_N182 3.8798345399e+05
R_Conv_1_7_0_0_2_2_0 L0_N900 L1_N182 4.4022254443e+06
R_Conv_1_7_0_0_2_2_1 L0_N901 L1_N182 1.5358515901e+05
*
R_Conv_1_7_0_1_0_0_0 L0_N784 L1_N183 1.2123709737e+05
R_Conv_1_7_0_1_0_0_1 L0_N785 L1_N183 1.0849154640e+05
R_Conv_1_7_0_1_0_1_0 L0_N786 L1_N183 2.0480317885e+05
R_Conv_1_7_0_1_0_1_1 L0_N787 L1_N183 1.6641635952e+05
R_Conv_1_7_0_1_0_2_0 L0_N788 L1_N183 1.1683261279e+06
R_Conv_1_7_0_1_0_2_1 L0_N789 L1_N183 1.1602008983e+05
R_Conv_1_7_0_1_1_0_0 L0_N840 L1_N183 1.2296662853e+05
R_Conv_1_7_0_1_1_0_1 L0_N841 L1_N183 1.6882235068e+05
R_Conv_1_7_0_1_1_1_0 L0_N842 L1_N183 1.0472083211e+05
R_Conv_1_7_0_1_1_1_1 L0_N843 L1_N183 2.1167619859e+05
R_Conv_1_7_0_1_1_2_0 L0_N844 L1_N183 1.3518319025e+05
R_Conv_1_7_0_1_1_2_1 L0_N845 L1_N183 1.4280846670e+05
R_Conv_1_7_0_1_2_0_0 L0_N896 L1_N183 1.1620759255e+05
R_Conv_1_7_0_1_2_0_1 L0_N897 L1_N183 1.6895116802e+05
R_Conv_1_7_0_1_2_1_0 L0_N898 L1_N183 1.2455043512e+06
R_Conv_1_7_0_1_2_1_1 L0_N899 L1_N183 1.1694022847e+05
R_Conv_1_7_0_1_2_2_0 L0_N900 L1_N183 1.5663616684e+06
R_Conv_1_7_0_1_2_2_1 L0_N901 L1_N183 2.1466641264e+05
*
R_Conv_1_7_1_0_0_0_0 L0_N788 L1_N184 3.0927915375e+05
R_Conv_1_7_1_0_0_0_1 L0_N789 L1_N184 3.6154472179e+05
R_Conv_1_7_1_0_0_1_0 L0_N790 L1_N184 1.2307612303e+05
R_Conv_1_7_1_0_0_1_1 L0_N791 L1_N184 1.3361401953e+06
R_Conv_1_7_1_0_0_2_0 L0_N792 L1_N184 1.1771240850e+06
R_Conv_1_7_1_0_0_2_1 L0_N793 L1_N184 1.1947062568e+05
R_Conv_1_7_1_0_1_0_0 L0_N844 L1_N184 3.4555602430e+05
R_Conv_1_7_1_0_1_0_1 L0_N845 L1_N184 1.2140655673e+05
R_Conv_1_7_1_0_1_1_0 L0_N846 L1_N184 2.0024008865e+05
R_Conv_1_7_1_0_1_1_1 L0_N847 L1_N184 1.3019124074e+05
R_Conv_1_7_1_0_1_2_0 L0_N848 L1_N184 1.1085089352e+05
R_Conv_1_7_1_0_1_2_1 L0_N849 L1_N184 2.5251460583e+05
R_Conv_1_7_1_0_2_0_0 L0_N900 L1_N184 1.1040315248e+05
R_Conv_1_7_1_0_2_0_1 L0_N901 L1_N184 1.2105931856e+05
R_Conv_1_7_1_0_2_1_0 L0_N902 L1_N184 1.0186236681e+05
R_Conv_1_7_1_0_2_1_1 L0_N903 L1_N184 3.8798345399e+05
R_Conv_1_7_1_0_2_2_0 L0_N904 L1_N184 4.4022254443e+06
R_Conv_1_7_1_0_2_2_1 L0_N905 L1_N184 1.5358515901e+05
*
R_Conv_1_7_1_1_0_0_0 L0_N788 L1_N185 1.2123709737e+05
R_Conv_1_7_1_1_0_0_1 L0_N789 L1_N185 1.0849154640e+05
R_Conv_1_7_1_1_0_1_0 L0_N790 L1_N185 2.0480317885e+05
R_Conv_1_7_1_1_0_1_1 L0_N791 L1_N185 1.6641635952e+05
R_Conv_1_7_1_1_0_2_0 L0_N792 L1_N185 1.1683261279e+06
R_Conv_1_7_1_1_0_2_1 L0_N793 L1_N185 1.1602008983e+05
R_Conv_1_7_1_1_1_0_0 L0_N844 L1_N185 1.2296662853e+05
R_Conv_1_7_1_1_1_0_1 L0_N845 L1_N185 1.6882235068e+05
R_Conv_1_7_1_1_1_1_0 L0_N846 L1_N185 1.0472083211e+05
R_Conv_1_7_1_1_1_1_1 L0_N847 L1_N185 2.1167619859e+05
R_Conv_1_7_1_1_1_2_0 L0_N848 L1_N185 1.3518319025e+05
R_Conv_1_7_1_1_1_2_1 L0_N849 L1_N185 1.4280846670e+05
R_Conv_1_7_1_1_2_0_0 L0_N900 L1_N185 1.1620759255e+05
R_Conv_1_7_1_1_2_0_1 L0_N901 L1_N185 1.6895116802e+05
R_Conv_1_7_1_1_2_1_0 L0_N902 L1_N185 1.2455043512e+06
R_Conv_1_7_1_1_2_1_1 L0_N903 L1_N185 1.1694022847e+05
R_Conv_1_7_1_1_2_2_0 L0_N904 L1_N185 1.5663616684e+06
R_Conv_1_7_1_1_2_2_1 L0_N905 L1_N185 2.1466641264e+05
*
R_Conv_1_7_2_0_0_0_0 L0_N792 L1_N186 3.0927915375e+05
R_Conv_1_7_2_0_0_0_1 L0_N793 L1_N186 3.6154472179e+05
R_Conv_1_7_2_0_0_1_0 L0_N794 L1_N186 1.2307612303e+05
R_Conv_1_7_2_0_0_1_1 L0_N795 L1_N186 1.3361401953e+06
R_Conv_1_7_2_0_0_2_0 L0_N796 L1_N186 1.1771240850e+06
R_Conv_1_7_2_0_0_2_1 L0_N797 L1_N186 1.1947062568e+05
R_Conv_1_7_2_0_1_0_0 L0_N848 L1_N186 3.4555602430e+05
R_Conv_1_7_2_0_1_0_1 L0_N849 L1_N186 1.2140655673e+05
R_Conv_1_7_2_0_1_1_0 L0_N850 L1_N186 2.0024008865e+05
R_Conv_1_7_2_0_1_1_1 L0_N851 L1_N186 1.3019124074e+05
R_Conv_1_7_2_0_1_2_0 L0_N852 L1_N186 1.1085089352e+05
R_Conv_1_7_2_0_1_2_1 L0_N853 L1_N186 2.5251460583e+05
R_Conv_1_7_2_0_2_0_0 L0_N904 L1_N186 1.1040315248e+05
R_Conv_1_7_2_0_2_0_1 L0_N905 L1_N186 1.2105931856e+05
R_Conv_1_7_2_0_2_1_0 L0_N906 L1_N186 1.0186236681e+05
R_Conv_1_7_2_0_2_1_1 L0_N907 L1_N186 3.8798345399e+05
R_Conv_1_7_2_0_2_2_0 L0_N908 L1_N186 4.4022254443e+06
R_Conv_1_7_2_0_2_2_1 L0_N909 L1_N186 1.5358515901e+05
*
R_Conv_1_7_2_1_0_0_0 L0_N792 L1_N187 1.2123709737e+05
R_Conv_1_7_2_1_0_0_1 L0_N793 L1_N187 1.0849154640e+05
R_Conv_1_7_2_1_0_1_0 L0_N794 L1_N187 2.0480317885e+05
R_Conv_1_7_2_1_0_1_1 L0_N795 L1_N187 1.6641635952e+05
R_Conv_1_7_2_1_0_2_0 L0_N796 L1_N187 1.1683261279e+06
R_Conv_1_7_2_1_0_2_1 L0_N797 L1_N187 1.1602008983e+05
R_Conv_1_7_2_1_1_0_0 L0_N848 L1_N187 1.2296662853e+05
R_Conv_1_7_2_1_1_0_1 L0_N849 L1_N187 1.6882235068e+05
R_Conv_1_7_2_1_1_1_0 L0_N850 L1_N187 1.0472083211e+05
R_Conv_1_7_2_1_1_1_1 L0_N851 L1_N187 2.1167619859e+05
R_Conv_1_7_2_1_1_2_0 L0_N852 L1_N187 1.3518319025e+05
R_Conv_1_7_2_1_1_2_1 L0_N853 L1_N187 1.4280846670e+05
R_Conv_1_7_2_1_2_0_0 L0_N904 L1_N187 1.1620759255e+05
R_Conv_1_7_2_1_2_0_1 L0_N905 L1_N187 1.6895116802e+05
R_Conv_1_7_2_1_2_1_0 L0_N906 L1_N187 1.2455043512e+06
R_Conv_1_7_2_1_2_1_1 L0_N907 L1_N187 1.1694022847e+05
R_Conv_1_7_2_1_2_2_0 L0_N908 L1_N187 1.5663616684e+06
R_Conv_1_7_2_1_2_2_1 L0_N909 L1_N187 2.1466641264e+05
*
R_Conv_1_7_3_0_0_0_0 L0_N796 L1_N188 3.0927915375e+05
R_Conv_1_7_3_0_0_0_1 L0_N797 L1_N188 3.6154472179e+05
R_Conv_1_7_3_0_0_1_0 L0_N798 L1_N188 1.2307612303e+05
R_Conv_1_7_3_0_0_1_1 L0_N799 L1_N188 1.3361401953e+06
R_Conv_1_7_3_0_0_2_0 L0_N800 L1_N188 1.1771240850e+06
R_Conv_1_7_3_0_0_2_1 L0_N801 L1_N188 1.1947062568e+05
R_Conv_1_7_3_0_1_0_0 L0_N852 L1_N188 3.4555602430e+05
R_Conv_1_7_3_0_1_0_1 L0_N853 L1_N188 1.2140655673e+05
R_Conv_1_7_3_0_1_1_0 L0_N854 L1_N188 2.0024008865e+05
R_Conv_1_7_3_0_1_1_1 L0_N855 L1_N188 1.3019124074e+05
R_Conv_1_7_3_0_1_2_0 L0_N856 L1_N188 1.1085089352e+05
R_Conv_1_7_3_0_1_2_1 L0_N857 L1_N188 2.5251460583e+05
R_Conv_1_7_3_0_2_0_0 L0_N908 L1_N188 1.1040315248e+05
R_Conv_1_7_3_0_2_0_1 L0_N909 L1_N188 1.2105931856e+05
R_Conv_1_7_3_0_2_1_0 L0_N910 L1_N188 1.0186236681e+05
R_Conv_1_7_3_0_2_1_1 L0_N911 L1_N188 3.8798345399e+05
R_Conv_1_7_3_0_2_2_0 L0_N912 L1_N188 4.4022254443e+06
R_Conv_1_7_3_0_2_2_1 L0_N913 L1_N188 1.5358515901e+05
*
R_Conv_1_7_3_1_0_0_0 L0_N796 L1_N189 1.2123709737e+05
R_Conv_1_7_3_1_0_0_1 L0_N797 L1_N189 1.0849154640e+05
R_Conv_1_7_3_1_0_1_0 L0_N798 L1_N189 2.0480317885e+05
R_Conv_1_7_3_1_0_1_1 L0_N799 L1_N189 1.6641635952e+05
R_Conv_1_7_3_1_0_2_0 L0_N800 L1_N189 1.1683261279e+06
R_Conv_1_7_3_1_0_2_1 L0_N801 L1_N189 1.1602008983e+05
R_Conv_1_7_3_1_1_0_0 L0_N852 L1_N189 1.2296662853e+05
R_Conv_1_7_3_1_1_0_1 L0_N853 L1_N189 1.6882235068e+05
R_Conv_1_7_3_1_1_1_0 L0_N854 L1_N189 1.0472083211e+05
R_Conv_1_7_3_1_1_1_1 L0_N855 L1_N189 2.1167619859e+05
R_Conv_1_7_3_1_1_2_0 L0_N856 L1_N189 1.3518319025e+05
R_Conv_1_7_3_1_1_2_1 L0_N857 L1_N189 1.4280846670e+05
R_Conv_1_7_3_1_2_0_0 L0_N908 L1_N189 1.1620759255e+05
R_Conv_1_7_3_1_2_0_1 L0_N909 L1_N189 1.6895116802e+05
R_Conv_1_7_3_1_2_1_0 L0_N910 L1_N189 1.2455043512e+06
R_Conv_1_7_3_1_2_1_1 L0_N911 L1_N189 1.1694022847e+05
R_Conv_1_7_3_1_2_2_0 L0_N912 L1_N189 1.5663616684e+06
R_Conv_1_7_3_1_2_2_1 L0_N913 L1_N189 2.1466641264e+05
*
R_Conv_1_7_4_0_0_0_0 L0_N800 L1_N190 3.0927915375e+05
R_Conv_1_7_4_0_0_0_1 L0_N801 L1_N190 3.6154472179e+05
R_Conv_1_7_4_0_0_1_0 L0_N802 L1_N190 1.2307612303e+05
R_Conv_1_7_4_0_0_1_1 L0_N803 L1_N190 1.3361401953e+06
R_Conv_1_7_4_0_0_2_0 L0_N804 L1_N190 1.1771240850e+06
R_Conv_1_7_4_0_0_2_1 L0_N805 L1_N190 1.1947062568e+05
R_Conv_1_7_4_0_1_0_0 L0_N856 L1_N190 3.4555602430e+05
R_Conv_1_7_4_0_1_0_1 L0_N857 L1_N190 1.2140655673e+05
R_Conv_1_7_4_0_1_1_0 L0_N858 L1_N190 2.0024008865e+05
R_Conv_1_7_4_0_1_1_1 L0_N859 L1_N190 1.3019124074e+05
R_Conv_1_7_4_0_1_2_0 L0_N860 L1_N190 1.1085089352e+05
R_Conv_1_7_4_0_1_2_1 L0_N861 L1_N190 2.5251460583e+05
R_Conv_1_7_4_0_2_0_0 L0_N912 L1_N190 1.1040315248e+05
R_Conv_1_7_4_0_2_0_1 L0_N913 L1_N190 1.2105931856e+05
R_Conv_1_7_4_0_2_1_0 L0_N914 L1_N190 1.0186236681e+05
R_Conv_1_7_4_0_2_1_1 L0_N915 L1_N190 3.8798345399e+05
R_Conv_1_7_4_0_2_2_0 L0_N916 L1_N190 4.4022254443e+06
R_Conv_1_7_4_0_2_2_1 L0_N917 L1_N190 1.5358515901e+05
*
R_Conv_1_7_4_1_0_0_0 L0_N800 L1_N191 1.2123709737e+05
R_Conv_1_7_4_1_0_0_1 L0_N801 L1_N191 1.0849154640e+05
R_Conv_1_7_4_1_0_1_0 L0_N802 L1_N191 2.0480317885e+05
R_Conv_1_7_4_1_0_1_1 L0_N803 L1_N191 1.6641635952e+05
R_Conv_1_7_4_1_0_2_0 L0_N804 L1_N191 1.1683261279e+06
R_Conv_1_7_4_1_0_2_1 L0_N805 L1_N191 1.1602008983e+05
R_Conv_1_7_4_1_1_0_0 L0_N856 L1_N191 1.2296662853e+05
R_Conv_1_7_4_1_1_0_1 L0_N857 L1_N191 1.6882235068e+05
R_Conv_1_7_4_1_1_1_0 L0_N858 L1_N191 1.0472083211e+05
R_Conv_1_7_4_1_1_1_1 L0_N859 L1_N191 2.1167619859e+05
R_Conv_1_7_4_1_1_2_0 L0_N860 L1_N191 1.3518319025e+05
R_Conv_1_7_4_1_1_2_1 L0_N861 L1_N191 1.4280846670e+05
R_Conv_1_7_4_1_2_0_0 L0_N912 L1_N191 1.1620759255e+05
R_Conv_1_7_4_1_2_0_1 L0_N913 L1_N191 1.6895116802e+05
R_Conv_1_7_4_1_2_1_0 L0_N914 L1_N191 1.2455043512e+06
R_Conv_1_7_4_1_2_1_1 L0_N915 L1_N191 1.1694022847e+05
R_Conv_1_7_4_1_2_2_0 L0_N916 L1_N191 1.5663616684e+06
R_Conv_1_7_4_1_2_2_1 L0_N917 L1_N191 2.1466641264e+05
*
R_Conv_1_7_5_0_0_0_0 L0_N804 L1_N192 3.0927915375e+05
R_Conv_1_7_5_0_0_0_1 L0_N805 L1_N192 3.6154472179e+05
R_Conv_1_7_5_0_0_1_0 L0_N806 L1_N192 1.2307612303e+05
R_Conv_1_7_5_0_0_1_1 L0_N807 L1_N192 1.3361401953e+06
R_Conv_1_7_5_0_0_2_0 L0_N808 L1_N192 1.1771240850e+06
R_Conv_1_7_5_0_0_2_1 L0_N809 L1_N192 1.1947062568e+05
R_Conv_1_7_5_0_1_0_0 L0_N860 L1_N192 3.4555602430e+05
R_Conv_1_7_5_0_1_0_1 L0_N861 L1_N192 1.2140655673e+05
R_Conv_1_7_5_0_1_1_0 L0_N862 L1_N192 2.0024008865e+05
R_Conv_1_7_5_0_1_1_1 L0_N863 L1_N192 1.3019124074e+05
R_Conv_1_7_5_0_1_2_0 L0_N864 L1_N192 1.1085089352e+05
R_Conv_1_7_5_0_1_2_1 L0_N865 L1_N192 2.5251460583e+05
R_Conv_1_7_5_0_2_0_0 L0_N916 L1_N192 1.1040315248e+05
R_Conv_1_7_5_0_2_0_1 L0_N917 L1_N192 1.2105931856e+05
R_Conv_1_7_5_0_2_1_0 L0_N918 L1_N192 1.0186236681e+05
R_Conv_1_7_5_0_2_1_1 L0_N919 L1_N192 3.8798345399e+05
R_Conv_1_7_5_0_2_2_0 L0_N920 L1_N192 4.4022254443e+06
R_Conv_1_7_5_0_2_2_1 L0_N921 L1_N192 1.5358515901e+05
*
R_Conv_1_7_5_1_0_0_0 L0_N804 L1_N193 1.2123709737e+05
R_Conv_1_7_5_1_0_0_1 L0_N805 L1_N193 1.0849154640e+05
R_Conv_1_7_5_1_0_1_0 L0_N806 L1_N193 2.0480317885e+05
R_Conv_1_7_5_1_0_1_1 L0_N807 L1_N193 1.6641635952e+05
R_Conv_1_7_5_1_0_2_0 L0_N808 L1_N193 1.1683261279e+06
R_Conv_1_7_5_1_0_2_1 L0_N809 L1_N193 1.1602008983e+05
R_Conv_1_7_5_1_1_0_0 L0_N860 L1_N193 1.2296662853e+05
R_Conv_1_7_5_1_1_0_1 L0_N861 L1_N193 1.6882235068e+05
R_Conv_1_7_5_1_1_1_0 L0_N862 L1_N193 1.0472083211e+05
R_Conv_1_7_5_1_1_1_1 L0_N863 L1_N193 2.1167619859e+05
R_Conv_1_7_5_1_1_2_0 L0_N864 L1_N193 1.3518319025e+05
R_Conv_1_7_5_1_1_2_1 L0_N865 L1_N193 1.4280846670e+05
R_Conv_1_7_5_1_2_0_0 L0_N916 L1_N193 1.1620759255e+05
R_Conv_1_7_5_1_2_0_1 L0_N917 L1_N193 1.6895116802e+05
R_Conv_1_7_5_1_2_1_0 L0_N918 L1_N193 1.2455043512e+06
R_Conv_1_7_5_1_2_1_1 L0_N919 L1_N193 1.1694022847e+05
R_Conv_1_7_5_1_2_2_0 L0_N920 L1_N193 1.5663616684e+06
R_Conv_1_7_5_1_2_2_1 L0_N921 L1_N193 2.1466641264e+05
*
R_Conv_1_7_6_0_0_0_0 L0_N808 L1_N194 3.0927915375e+05
R_Conv_1_7_6_0_0_0_1 L0_N809 L1_N194 3.6154472179e+05
R_Conv_1_7_6_0_0_1_0 L0_N810 L1_N194 1.2307612303e+05
R_Conv_1_7_6_0_0_1_1 L0_N811 L1_N194 1.3361401953e+06
R_Conv_1_7_6_0_0_2_0 L0_N812 L1_N194 1.1771240850e+06
R_Conv_1_7_6_0_0_2_1 L0_N813 L1_N194 1.1947062568e+05
R_Conv_1_7_6_0_1_0_0 L0_N864 L1_N194 3.4555602430e+05
R_Conv_1_7_6_0_1_0_1 L0_N865 L1_N194 1.2140655673e+05
R_Conv_1_7_6_0_1_1_0 L0_N866 L1_N194 2.0024008865e+05
R_Conv_1_7_6_0_1_1_1 L0_N867 L1_N194 1.3019124074e+05
R_Conv_1_7_6_0_1_2_0 L0_N868 L1_N194 1.1085089352e+05
R_Conv_1_7_6_0_1_2_1 L0_N869 L1_N194 2.5251460583e+05
R_Conv_1_7_6_0_2_0_0 L0_N920 L1_N194 1.1040315248e+05
R_Conv_1_7_6_0_2_0_1 L0_N921 L1_N194 1.2105931856e+05
R_Conv_1_7_6_0_2_1_0 L0_N922 L1_N194 1.0186236681e+05
R_Conv_1_7_6_0_2_1_1 L0_N923 L1_N194 3.8798345399e+05
R_Conv_1_7_6_0_2_2_0 L0_N924 L1_N194 4.4022254443e+06
R_Conv_1_7_6_0_2_2_1 L0_N925 L1_N194 1.5358515901e+05
*
R_Conv_1_7_6_1_0_0_0 L0_N808 L1_N195 1.2123709737e+05
R_Conv_1_7_6_1_0_0_1 L0_N809 L1_N195 1.0849154640e+05
R_Conv_1_7_6_1_0_1_0 L0_N810 L1_N195 2.0480317885e+05
R_Conv_1_7_6_1_0_1_1 L0_N811 L1_N195 1.6641635952e+05
R_Conv_1_7_6_1_0_2_0 L0_N812 L1_N195 1.1683261279e+06
R_Conv_1_7_6_1_0_2_1 L0_N813 L1_N195 1.1602008983e+05
R_Conv_1_7_6_1_1_0_0 L0_N864 L1_N195 1.2296662853e+05
R_Conv_1_7_6_1_1_0_1 L0_N865 L1_N195 1.6882235068e+05
R_Conv_1_7_6_1_1_1_0 L0_N866 L1_N195 1.0472083211e+05
R_Conv_1_7_6_1_1_1_1 L0_N867 L1_N195 2.1167619859e+05
R_Conv_1_7_6_1_1_2_0 L0_N868 L1_N195 1.3518319025e+05
R_Conv_1_7_6_1_1_2_1 L0_N869 L1_N195 1.4280846670e+05
R_Conv_1_7_6_1_2_0_0 L0_N920 L1_N195 1.1620759255e+05
R_Conv_1_7_6_1_2_0_1 L0_N921 L1_N195 1.6895116802e+05
R_Conv_1_7_6_1_2_1_0 L0_N922 L1_N195 1.2455043512e+06
R_Conv_1_7_6_1_2_1_1 L0_N923 L1_N195 1.1694022847e+05
R_Conv_1_7_6_1_2_2_0 L0_N924 L1_N195 1.5663616684e+06
R_Conv_1_7_6_1_2_2_1 L0_N925 L1_N195 2.1466641264e+05
*
R_Conv_1_7_7_0_0_0_0 L0_N812 L1_N196 3.0927915375e+05
R_Conv_1_7_7_0_0_0_1 L0_N813 L1_N196 3.6154472179e+05
R_Conv_1_7_7_0_0_1_0 L0_N814 L1_N196 1.2307612303e+05
R_Conv_1_7_7_0_0_1_1 L0_N815 L1_N196 1.3361401953e+06
R_Conv_1_7_7_0_0_2_0 L0_N816 L1_N196 1.1771240850e+06
R_Conv_1_7_7_0_0_2_1 L0_N817 L1_N196 1.1947062568e+05
R_Conv_1_7_7_0_1_0_0 L0_N868 L1_N196 3.4555602430e+05
R_Conv_1_7_7_0_1_0_1 L0_N869 L1_N196 1.2140655673e+05
R_Conv_1_7_7_0_1_1_0 L0_N870 L1_N196 2.0024008865e+05
R_Conv_1_7_7_0_1_1_1 L0_N871 L1_N196 1.3019124074e+05
R_Conv_1_7_7_0_1_2_0 L0_N872 L1_N196 1.1085089352e+05
R_Conv_1_7_7_0_1_2_1 L0_N873 L1_N196 2.5251460583e+05
R_Conv_1_7_7_0_2_0_0 L0_N924 L1_N196 1.1040315248e+05
R_Conv_1_7_7_0_2_0_1 L0_N925 L1_N196 1.2105931856e+05
R_Conv_1_7_7_0_2_1_0 L0_N926 L1_N196 1.0186236681e+05
R_Conv_1_7_7_0_2_1_1 L0_N927 L1_N196 3.8798345399e+05
R_Conv_1_7_7_0_2_2_0 L0_N928 L1_N196 4.4022254443e+06
R_Conv_1_7_7_0_2_2_1 L0_N929 L1_N196 1.5358515901e+05
*
R_Conv_1_7_7_1_0_0_0 L0_N812 L1_N197 1.2123709737e+05
R_Conv_1_7_7_1_0_0_1 L0_N813 L1_N197 1.0849154640e+05
R_Conv_1_7_7_1_0_1_0 L0_N814 L1_N197 2.0480317885e+05
R_Conv_1_7_7_1_0_1_1 L0_N815 L1_N197 1.6641635952e+05
R_Conv_1_7_7_1_0_2_0 L0_N816 L1_N197 1.1683261279e+06
R_Conv_1_7_7_1_0_2_1 L0_N817 L1_N197 1.1602008983e+05
R_Conv_1_7_7_1_1_0_0 L0_N868 L1_N197 1.2296662853e+05
R_Conv_1_7_7_1_1_0_1 L0_N869 L1_N197 1.6882235068e+05
R_Conv_1_7_7_1_1_1_0 L0_N870 L1_N197 1.0472083211e+05
R_Conv_1_7_7_1_1_1_1 L0_N871 L1_N197 2.1167619859e+05
R_Conv_1_7_7_1_1_2_0 L0_N872 L1_N197 1.3518319025e+05
R_Conv_1_7_7_1_1_2_1 L0_N873 L1_N197 1.4280846670e+05
R_Conv_1_7_7_1_2_0_0 L0_N924 L1_N197 1.1620759255e+05
R_Conv_1_7_7_1_2_0_1 L0_N925 L1_N197 1.6895116802e+05
R_Conv_1_7_7_1_2_1_0 L0_N926 L1_N197 1.2455043512e+06
R_Conv_1_7_7_1_2_1_1 L0_N927 L1_N197 1.1694022847e+05
R_Conv_1_7_7_1_2_2_0 L0_N928 L1_N197 1.5663616684e+06
R_Conv_1_7_7_1_2_2_1 L0_N929 L1_N197 2.1466641264e+05
*
R_Conv_1_7_8_0_0_0_0 L0_N816 L1_N198 3.0927915375e+05
R_Conv_1_7_8_0_0_0_1 L0_N817 L1_N198 3.6154472179e+05
R_Conv_1_7_8_0_0_1_0 L0_N818 L1_N198 1.2307612303e+05
R_Conv_1_7_8_0_0_1_1 L0_N819 L1_N198 1.3361401953e+06
R_Conv_1_7_8_0_0_2_0 L0_N820 L1_N198 1.1771240850e+06
R_Conv_1_7_8_0_0_2_1 L0_N821 L1_N198 1.1947062568e+05
R_Conv_1_7_8_0_1_0_0 L0_N872 L1_N198 3.4555602430e+05
R_Conv_1_7_8_0_1_0_1 L0_N873 L1_N198 1.2140655673e+05
R_Conv_1_7_8_0_1_1_0 L0_N874 L1_N198 2.0024008865e+05
R_Conv_1_7_8_0_1_1_1 L0_N875 L1_N198 1.3019124074e+05
R_Conv_1_7_8_0_1_2_0 L0_N876 L1_N198 1.1085089352e+05
R_Conv_1_7_8_0_1_2_1 L0_N877 L1_N198 2.5251460583e+05
R_Conv_1_7_8_0_2_0_0 L0_N928 L1_N198 1.1040315248e+05
R_Conv_1_7_8_0_2_0_1 L0_N929 L1_N198 1.2105931856e+05
R_Conv_1_7_8_0_2_1_0 L0_N930 L1_N198 1.0186236681e+05
R_Conv_1_7_8_0_2_1_1 L0_N931 L1_N198 3.8798345399e+05
R_Conv_1_7_8_0_2_2_0 L0_N932 L1_N198 4.4022254443e+06
R_Conv_1_7_8_0_2_2_1 L0_N933 L1_N198 1.5358515901e+05
*
R_Conv_1_7_8_1_0_0_0 L0_N816 L1_N199 1.2123709737e+05
R_Conv_1_7_8_1_0_0_1 L0_N817 L1_N199 1.0849154640e+05
R_Conv_1_7_8_1_0_1_0 L0_N818 L1_N199 2.0480317885e+05
R_Conv_1_7_8_1_0_1_1 L0_N819 L1_N199 1.6641635952e+05
R_Conv_1_7_8_1_0_2_0 L0_N820 L1_N199 1.1683261279e+06
R_Conv_1_7_8_1_0_2_1 L0_N821 L1_N199 1.1602008983e+05
R_Conv_1_7_8_1_1_0_0 L0_N872 L1_N199 1.2296662853e+05
R_Conv_1_7_8_1_1_0_1 L0_N873 L1_N199 1.6882235068e+05
R_Conv_1_7_8_1_1_1_0 L0_N874 L1_N199 1.0472083211e+05
R_Conv_1_7_8_1_1_1_1 L0_N875 L1_N199 2.1167619859e+05
R_Conv_1_7_8_1_1_2_0 L0_N876 L1_N199 1.3518319025e+05
R_Conv_1_7_8_1_1_2_1 L0_N877 L1_N199 1.4280846670e+05
R_Conv_1_7_8_1_2_0_0 L0_N928 L1_N199 1.1620759255e+05
R_Conv_1_7_8_1_2_0_1 L0_N929 L1_N199 1.6895116802e+05
R_Conv_1_7_8_1_2_1_0 L0_N930 L1_N199 1.2455043512e+06
R_Conv_1_7_8_1_2_1_1 L0_N931 L1_N199 1.1694022847e+05
R_Conv_1_7_8_1_2_2_0 L0_N932 L1_N199 1.5663616684e+06
R_Conv_1_7_8_1_2_2_1 L0_N933 L1_N199 2.1466641264e+05
*
R_Conv_1_7_9_0_0_0_0 L0_N820 L1_N200 3.0927915375e+05
R_Conv_1_7_9_0_0_0_1 L0_N821 L1_N200 3.6154472179e+05
R_Conv_1_7_9_0_0_1_0 L0_N822 L1_N200 1.2307612303e+05
R_Conv_1_7_9_0_0_1_1 L0_N823 L1_N200 1.3361401953e+06
R_Conv_1_7_9_0_0_2_0 L0_N824 L1_N200 1.1771240850e+06
R_Conv_1_7_9_0_0_2_1 L0_N825 L1_N200 1.1947062568e+05
R_Conv_1_7_9_0_1_0_0 L0_N876 L1_N200 3.4555602430e+05
R_Conv_1_7_9_0_1_0_1 L0_N877 L1_N200 1.2140655673e+05
R_Conv_1_7_9_0_1_1_0 L0_N878 L1_N200 2.0024008865e+05
R_Conv_1_7_9_0_1_1_1 L0_N879 L1_N200 1.3019124074e+05
R_Conv_1_7_9_0_1_2_0 L0_N880 L1_N200 1.1085089352e+05
R_Conv_1_7_9_0_1_2_1 L0_N881 L1_N200 2.5251460583e+05
R_Conv_1_7_9_0_2_0_0 L0_N932 L1_N200 1.1040315248e+05
R_Conv_1_7_9_0_2_0_1 L0_N933 L1_N200 1.2105931856e+05
R_Conv_1_7_9_0_2_1_0 L0_N934 L1_N200 1.0186236681e+05
R_Conv_1_7_9_0_2_1_1 L0_N935 L1_N200 3.8798345399e+05
R_Conv_1_7_9_0_2_2_0 L0_N936 L1_N200 4.4022254443e+06
R_Conv_1_7_9_0_2_2_1 L0_N937 L1_N200 1.5358515901e+05
*
R_Conv_1_7_9_1_0_0_0 L0_N820 L1_N201 1.2123709737e+05
R_Conv_1_7_9_1_0_0_1 L0_N821 L1_N201 1.0849154640e+05
R_Conv_1_7_9_1_0_1_0 L0_N822 L1_N201 2.0480317885e+05
R_Conv_1_7_9_1_0_1_1 L0_N823 L1_N201 1.6641635952e+05
R_Conv_1_7_9_1_0_2_0 L0_N824 L1_N201 1.1683261279e+06
R_Conv_1_7_9_1_0_2_1 L0_N825 L1_N201 1.1602008983e+05
R_Conv_1_7_9_1_1_0_0 L0_N876 L1_N201 1.2296662853e+05
R_Conv_1_7_9_1_1_0_1 L0_N877 L1_N201 1.6882235068e+05
R_Conv_1_7_9_1_1_1_0 L0_N878 L1_N201 1.0472083211e+05
R_Conv_1_7_9_1_1_1_1 L0_N879 L1_N201 2.1167619859e+05
R_Conv_1_7_9_1_1_2_0 L0_N880 L1_N201 1.3518319025e+05
R_Conv_1_7_9_1_1_2_1 L0_N881 L1_N201 1.4280846670e+05
R_Conv_1_7_9_1_2_0_0 L0_N932 L1_N201 1.1620759255e+05
R_Conv_1_7_9_1_2_0_1 L0_N933 L1_N201 1.6895116802e+05
R_Conv_1_7_9_1_2_1_0 L0_N934 L1_N201 1.2455043512e+06
R_Conv_1_7_9_1_2_1_1 L0_N935 L1_N201 1.1694022847e+05
R_Conv_1_7_9_1_2_2_0 L0_N936 L1_N201 1.5663616684e+06
R_Conv_1_7_9_1_2_2_1 L0_N937 L1_N201 2.1466641264e+05
*
R_Conv_1_7_10_0_0_0_0 L0_N824 L1_N202 3.0927915375e+05
R_Conv_1_7_10_0_0_0_1 L0_N825 L1_N202 3.6154472179e+05
R_Conv_1_7_10_0_0_1_0 L0_N826 L1_N202 1.2307612303e+05
R_Conv_1_7_10_0_0_1_1 L0_N827 L1_N202 1.3361401953e+06
R_Conv_1_7_10_0_0_2_0 L0_N828 L1_N202 1.1771240850e+06
R_Conv_1_7_10_0_0_2_1 L0_N829 L1_N202 1.1947062568e+05
R_Conv_1_7_10_0_1_0_0 L0_N880 L1_N202 3.4555602430e+05
R_Conv_1_7_10_0_1_0_1 L0_N881 L1_N202 1.2140655673e+05
R_Conv_1_7_10_0_1_1_0 L0_N882 L1_N202 2.0024008865e+05
R_Conv_1_7_10_0_1_1_1 L0_N883 L1_N202 1.3019124074e+05
R_Conv_1_7_10_0_1_2_0 L0_N884 L1_N202 1.1085089352e+05
R_Conv_1_7_10_0_1_2_1 L0_N885 L1_N202 2.5251460583e+05
R_Conv_1_7_10_0_2_0_0 L0_N936 L1_N202 1.1040315248e+05
R_Conv_1_7_10_0_2_0_1 L0_N937 L1_N202 1.2105931856e+05
R_Conv_1_7_10_0_2_1_0 L0_N938 L1_N202 1.0186236681e+05
R_Conv_1_7_10_0_2_1_1 L0_N939 L1_N202 3.8798345399e+05
R_Conv_1_7_10_0_2_2_0 L0_N940 L1_N202 4.4022254443e+06
R_Conv_1_7_10_0_2_2_1 L0_N941 L1_N202 1.5358515901e+05
*
R_Conv_1_7_10_1_0_0_0 L0_N824 L1_N203 1.2123709737e+05
R_Conv_1_7_10_1_0_0_1 L0_N825 L1_N203 1.0849154640e+05
R_Conv_1_7_10_1_0_1_0 L0_N826 L1_N203 2.0480317885e+05
R_Conv_1_7_10_1_0_1_1 L0_N827 L1_N203 1.6641635952e+05
R_Conv_1_7_10_1_0_2_0 L0_N828 L1_N203 1.1683261279e+06
R_Conv_1_7_10_1_0_2_1 L0_N829 L1_N203 1.1602008983e+05
R_Conv_1_7_10_1_1_0_0 L0_N880 L1_N203 1.2296662853e+05
R_Conv_1_7_10_1_1_0_1 L0_N881 L1_N203 1.6882235068e+05
R_Conv_1_7_10_1_1_1_0 L0_N882 L1_N203 1.0472083211e+05
R_Conv_1_7_10_1_1_1_1 L0_N883 L1_N203 2.1167619859e+05
R_Conv_1_7_10_1_1_2_0 L0_N884 L1_N203 1.3518319025e+05
R_Conv_1_7_10_1_1_2_1 L0_N885 L1_N203 1.4280846670e+05
R_Conv_1_7_10_1_2_0_0 L0_N936 L1_N203 1.1620759255e+05
R_Conv_1_7_10_1_2_0_1 L0_N937 L1_N203 1.6895116802e+05
R_Conv_1_7_10_1_2_1_0 L0_N938 L1_N203 1.2455043512e+06
R_Conv_1_7_10_1_2_1_1 L0_N939 L1_N203 1.1694022847e+05
R_Conv_1_7_10_1_2_2_0 L0_N940 L1_N203 1.5663616684e+06
R_Conv_1_7_10_1_2_2_1 L0_N941 L1_N203 2.1466641264e+05
*
R_Conv_1_7_11_0_0_0_0 L0_N828 L1_N204 3.0927915375e+05
R_Conv_1_7_11_0_0_0_1 L0_N829 L1_N204 3.6154472179e+05
R_Conv_1_7_11_0_0_1_0 L0_N830 L1_N204 1.2307612303e+05
R_Conv_1_7_11_0_0_1_1 L0_N831 L1_N204 1.3361401953e+06
R_Conv_1_7_11_0_0_2_0 L0_N832 L1_N204 1.1771240850e+06
R_Conv_1_7_11_0_0_2_1 L0_N833 L1_N204 1.1947062568e+05
R_Conv_1_7_11_0_1_0_0 L0_N884 L1_N204 3.4555602430e+05
R_Conv_1_7_11_0_1_0_1 L0_N885 L1_N204 1.2140655673e+05
R_Conv_1_7_11_0_1_1_0 L0_N886 L1_N204 2.0024008865e+05
R_Conv_1_7_11_0_1_1_1 L0_N887 L1_N204 1.3019124074e+05
R_Conv_1_7_11_0_1_2_0 L0_N888 L1_N204 1.1085089352e+05
R_Conv_1_7_11_0_1_2_1 L0_N889 L1_N204 2.5251460583e+05
R_Conv_1_7_11_0_2_0_0 L0_N940 L1_N204 1.1040315248e+05
R_Conv_1_7_11_0_2_0_1 L0_N941 L1_N204 1.2105931856e+05
R_Conv_1_7_11_0_2_1_0 L0_N942 L1_N204 1.0186236681e+05
R_Conv_1_7_11_0_2_1_1 L0_N943 L1_N204 3.8798345399e+05
R_Conv_1_7_11_0_2_2_0 L0_N944 L1_N204 4.4022254443e+06
R_Conv_1_7_11_0_2_2_1 L0_N945 L1_N204 1.5358515901e+05
*
R_Conv_1_7_11_1_0_0_0 L0_N828 L1_N205 1.2123709737e+05
R_Conv_1_7_11_1_0_0_1 L0_N829 L1_N205 1.0849154640e+05
R_Conv_1_7_11_1_0_1_0 L0_N830 L1_N205 2.0480317885e+05
R_Conv_1_7_11_1_0_1_1 L0_N831 L1_N205 1.6641635952e+05
R_Conv_1_7_11_1_0_2_0 L0_N832 L1_N205 1.1683261279e+06
R_Conv_1_7_11_1_0_2_1 L0_N833 L1_N205 1.1602008983e+05
R_Conv_1_7_11_1_1_0_0 L0_N884 L1_N205 1.2296662853e+05
R_Conv_1_7_11_1_1_0_1 L0_N885 L1_N205 1.6882235068e+05
R_Conv_1_7_11_1_1_1_0 L0_N886 L1_N205 1.0472083211e+05
R_Conv_1_7_11_1_1_1_1 L0_N887 L1_N205 2.1167619859e+05
R_Conv_1_7_11_1_1_2_0 L0_N888 L1_N205 1.3518319025e+05
R_Conv_1_7_11_1_1_2_1 L0_N889 L1_N205 1.4280846670e+05
R_Conv_1_7_11_1_2_0_0 L0_N940 L1_N205 1.1620759255e+05
R_Conv_1_7_11_1_2_0_1 L0_N941 L1_N205 1.6895116802e+05
R_Conv_1_7_11_1_2_1_0 L0_N942 L1_N205 1.2455043512e+06
R_Conv_1_7_11_1_2_1_1 L0_N943 L1_N205 1.1694022847e+05
R_Conv_1_7_11_1_2_2_0 L0_N944 L1_N205 1.5663616684e+06
R_Conv_1_7_11_1_2_2_1 L0_N945 L1_N205 2.1466641264e+05
*
R_Conv_1_7_12_0_0_0_0 L0_N832 L1_N206 3.0927915375e+05
R_Conv_1_7_12_0_0_0_1 L0_N833 L1_N206 3.6154472179e+05
R_Conv_1_7_12_0_0_1_0 L0_N834 L1_N206 1.2307612303e+05
R_Conv_1_7_12_0_0_1_1 L0_N835 L1_N206 1.3361401953e+06
R_Conv_1_7_12_0_0_2_0 L0_N836 L1_N206 1.1771240850e+06
R_Conv_1_7_12_0_0_2_1 L0_N837 L1_N206 1.1947062568e+05
R_Conv_1_7_12_0_1_0_0 L0_N888 L1_N206 3.4555602430e+05
R_Conv_1_7_12_0_1_0_1 L0_N889 L1_N206 1.2140655673e+05
R_Conv_1_7_12_0_1_1_0 L0_N890 L1_N206 2.0024008865e+05
R_Conv_1_7_12_0_1_1_1 L0_N891 L1_N206 1.3019124074e+05
R_Conv_1_7_12_0_1_2_0 L0_N892 L1_N206 1.1085089352e+05
R_Conv_1_7_12_0_1_2_1 L0_N893 L1_N206 2.5251460583e+05
R_Conv_1_7_12_0_2_0_0 L0_N944 L1_N206 1.1040315248e+05
R_Conv_1_7_12_0_2_0_1 L0_N945 L1_N206 1.2105931856e+05
R_Conv_1_7_12_0_2_1_0 L0_N946 L1_N206 1.0186236681e+05
R_Conv_1_7_12_0_2_1_1 L0_N947 L1_N206 3.8798345399e+05
R_Conv_1_7_12_0_2_2_0 L0_N948 L1_N206 4.4022254443e+06
R_Conv_1_7_12_0_2_2_1 L0_N949 L1_N206 1.5358515901e+05
*
R_Conv_1_7_12_1_0_0_0 L0_N832 L1_N207 1.2123709737e+05
R_Conv_1_7_12_1_0_0_1 L0_N833 L1_N207 1.0849154640e+05
R_Conv_1_7_12_1_0_1_0 L0_N834 L1_N207 2.0480317885e+05
R_Conv_1_7_12_1_0_1_1 L0_N835 L1_N207 1.6641635952e+05
R_Conv_1_7_12_1_0_2_0 L0_N836 L1_N207 1.1683261279e+06
R_Conv_1_7_12_1_0_2_1 L0_N837 L1_N207 1.1602008983e+05
R_Conv_1_7_12_1_1_0_0 L0_N888 L1_N207 1.2296662853e+05
R_Conv_1_7_12_1_1_0_1 L0_N889 L1_N207 1.6882235068e+05
R_Conv_1_7_12_1_1_1_0 L0_N890 L1_N207 1.0472083211e+05
R_Conv_1_7_12_1_1_1_1 L0_N891 L1_N207 2.1167619859e+05
R_Conv_1_7_12_1_1_2_0 L0_N892 L1_N207 1.3518319025e+05
R_Conv_1_7_12_1_1_2_1 L0_N893 L1_N207 1.4280846670e+05
R_Conv_1_7_12_1_2_0_0 L0_N944 L1_N207 1.1620759255e+05
R_Conv_1_7_12_1_2_0_1 L0_N945 L1_N207 1.6895116802e+05
R_Conv_1_7_12_1_2_1_0 L0_N946 L1_N207 1.2455043512e+06
R_Conv_1_7_12_1_2_1_1 L0_N947 L1_N207 1.1694022847e+05
R_Conv_1_7_12_1_2_2_0 L0_N948 L1_N207 1.5663616684e+06
R_Conv_1_7_12_1_2_2_1 L0_N949 L1_N207 2.1466641264e+05
*
R_Conv_1_8_0_0_0_0_0 L0_N896 L1_N208 3.0927915375e+05
R_Conv_1_8_0_0_0_0_1 L0_N897 L1_N208 3.6154472179e+05
R_Conv_1_8_0_0_0_1_0 L0_N898 L1_N208 1.2307612303e+05
R_Conv_1_8_0_0_0_1_1 L0_N899 L1_N208 1.3361401953e+06
R_Conv_1_8_0_0_0_2_0 L0_N900 L1_N208 1.1771240850e+06
R_Conv_1_8_0_0_0_2_1 L0_N901 L1_N208 1.1947062568e+05
R_Conv_1_8_0_0_1_0_0 L0_N952 L1_N208 3.4555602430e+05
R_Conv_1_8_0_0_1_0_1 L0_N953 L1_N208 1.2140655673e+05
R_Conv_1_8_0_0_1_1_0 L0_N954 L1_N208 2.0024008865e+05
R_Conv_1_8_0_0_1_1_1 L0_N955 L1_N208 1.3019124074e+05
R_Conv_1_8_0_0_1_2_0 L0_N956 L1_N208 1.1085089352e+05
R_Conv_1_8_0_0_1_2_1 L0_N957 L1_N208 2.5251460583e+05
R_Conv_1_8_0_0_2_0_0 L0_N1008 L1_N208 1.1040315248e+05
R_Conv_1_8_0_0_2_0_1 L0_N1009 L1_N208 1.2105931856e+05
R_Conv_1_8_0_0_2_1_0 L0_N1010 L1_N208 1.0186236681e+05
R_Conv_1_8_0_0_2_1_1 L0_N1011 L1_N208 3.8798345399e+05
R_Conv_1_8_0_0_2_2_0 L0_N1012 L1_N208 4.4022254443e+06
R_Conv_1_8_0_0_2_2_1 L0_N1013 L1_N208 1.5358515901e+05
*
R_Conv_1_8_0_1_0_0_0 L0_N896 L1_N209 1.2123709737e+05
R_Conv_1_8_0_1_0_0_1 L0_N897 L1_N209 1.0849154640e+05
R_Conv_1_8_0_1_0_1_0 L0_N898 L1_N209 2.0480317885e+05
R_Conv_1_8_0_1_0_1_1 L0_N899 L1_N209 1.6641635952e+05
R_Conv_1_8_0_1_0_2_0 L0_N900 L1_N209 1.1683261279e+06
R_Conv_1_8_0_1_0_2_1 L0_N901 L1_N209 1.1602008983e+05
R_Conv_1_8_0_1_1_0_0 L0_N952 L1_N209 1.2296662853e+05
R_Conv_1_8_0_1_1_0_1 L0_N953 L1_N209 1.6882235068e+05
R_Conv_1_8_0_1_1_1_0 L0_N954 L1_N209 1.0472083211e+05
R_Conv_1_8_0_1_1_1_1 L0_N955 L1_N209 2.1167619859e+05
R_Conv_1_8_0_1_1_2_0 L0_N956 L1_N209 1.3518319025e+05
R_Conv_1_8_0_1_1_2_1 L0_N957 L1_N209 1.4280846670e+05
R_Conv_1_8_0_1_2_0_0 L0_N1008 L1_N209 1.1620759255e+05
R_Conv_1_8_0_1_2_0_1 L0_N1009 L1_N209 1.6895116802e+05
R_Conv_1_8_0_1_2_1_0 L0_N1010 L1_N209 1.2455043512e+06
R_Conv_1_8_0_1_2_1_1 L0_N1011 L1_N209 1.1694022847e+05
R_Conv_1_8_0_1_2_2_0 L0_N1012 L1_N209 1.5663616684e+06
R_Conv_1_8_0_1_2_2_1 L0_N1013 L1_N209 2.1466641264e+05
*
R_Conv_1_8_1_0_0_0_0 L0_N900 L1_N210 3.0927915375e+05
R_Conv_1_8_1_0_0_0_1 L0_N901 L1_N210 3.6154472179e+05
R_Conv_1_8_1_0_0_1_0 L0_N902 L1_N210 1.2307612303e+05
R_Conv_1_8_1_0_0_1_1 L0_N903 L1_N210 1.3361401953e+06
R_Conv_1_8_1_0_0_2_0 L0_N904 L1_N210 1.1771240850e+06
R_Conv_1_8_1_0_0_2_1 L0_N905 L1_N210 1.1947062568e+05
R_Conv_1_8_1_0_1_0_0 L0_N956 L1_N210 3.4555602430e+05
R_Conv_1_8_1_0_1_0_1 L0_N957 L1_N210 1.2140655673e+05
R_Conv_1_8_1_0_1_1_0 L0_N958 L1_N210 2.0024008865e+05
R_Conv_1_8_1_0_1_1_1 L0_N959 L1_N210 1.3019124074e+05
R_Conv_1_8_1_0_1_2_0 L0_N960 L1_N210 1.1085089352e+05
R_Conv_1_8_1_0_1_2_1 L0_N961 L1_N210 2.5251460583e+05
R_Conv_1_8_1_0_2_0_0 L0_N1012 L1_N210 1.1040315248e+05
R_Conv_1_8_1_0_2_0_1 L0_N1013 L1_N210 1.2105931856e+05
R_Conv_1_8_1_0_2_1_0 L0_N1014 L1_N210 1.0186236681e+05
R_Conv_1_8_1_0_2_1_1 L0_N1015 L1_N210 3.8798345399e+05
R_Conv_1_8_1_0_2_2_0 L0_N1016 L1_N210 4.4022254443e+06
R_Conv_1_8_1_0_2_2_1 L0_N1017 L1_N210 1.5358515901e+05
*
R_Conv_1_8_1_1_0_0_0 L0_N900 L1_N211 1.2123709737e+05
R_Conv_1_8_1_1_0_0_1 L0_N901 L1_N211 1.0849154640e+05
R_Conv_1_8_1_1_0_1_0 L0_N902 L1_N211 2.0480317885e+05
R_Conv_1_8_1_1_0_1_1 L0_N903 L1_N211 1.6641635952e+05
R_Conv_1_8_1_1_0_2_0 L0_N904 L1_N211 1.1683261279e+06
R_Conv_1_8_1_1_0_2_1 L0_N905 L1_N211 1.1602008983e+05
R_Conv_1_8_1_1_1_0_0 L0_N956 L1_N211 1.2296662853e+05
R_Conv_1_8_1_1_1_0_1 L0_N957 L1_N211 1.6882235068e+05
R_Conv_1_8_1_1_1_1_0 L0_N958 L1_N211 1.0472083211e+05
R_Conv_1_8_1_1_1_1_1 L0_N959 L1_N211 2.1167619859e+05
R_Conv_1_8_1_1_1_2_0 L0_N960 L1_N211 1.3518319025e+05
R_Conv_1_8_1_1_1_2_1 L0_N961 L1_N211 1.4280846670e+05
R_Conv_1_8_1_1_2_0_0 L0_N1012 L1_N211 1.1620759255e+05
R_Conv_1_8_1_1_2_0_1 L0_N1013 L1_N211 1.6895116802e+05
R_Conv_1_8_1_1_2_1_0 L0_N1014 L1_N211 1.2455043512e+06
R_Conv_1_8_1_1_2_1_1 L0_N1015 L1_N211 1.1694022847e+05
R_Conv_1_8_1_1_2_2_0 L0_N1016 L1_N211 1.5663616684e+06
R_Conv_1_8_1_1_2_2_1 L0_N1017 L1_N211 2.1466641264e+05
*
R_Conv_1_8_2_0_0_0_0 L0_N904 L1_N212 3.0927915375e+05
R_Conv_1_8_2_0_0_0_1 L0_N905 L1_N212 3.6154472179e+05
R_Conv_1_8_2_0_0_1_0 L0_N906 L1_N212 1.2307612303e+05
R_Conv_1_8_2_0_0_1_1 L0_N907 L1_N212 1.3361401953e+06
R_Conv_1_8_2_0_0_2_0 L0_N908 L1_N212 1.1771240850e+06
R_Conv_1_8_2_0_0_2_1 L0_N909 L1_N212 1.1947062568e+05
R_Conv_1_8_2_0_1_0_0 L0_N960 L1_N212 3.4555602430e+05
R_Conv_1_8_2_0_1_0_1 L0_N961 L1_N212 1.2140655673e+05
R_Conv_1_8_2_0_1_1_0 L0_N962 L1_N212 2.0024008865e+05
R_Conv_1_8_2_0_1_1_1 L0_N963 L1_N212 1.3019124074e+05
R_Conv_1_8_2_0_1_2_0 L0_N964 L1_N212 1.1085089352e+05
R_Conv_1_8_2_0_1_2_1 L0_N965 L1_N212 2.5251460583e+05
R_Conv_1_8_2_0_2_0_0 L0_N1016 L1_N212 1.1040315248e+05
R_Conv_1_8_2_0_2_0_1 L0_N1017 L1_N212 1.2105931856e+05
R_Conv_1_8_2_0_2_1_0 L0_N1018 L1_N212 1.0186236681e+05
R_Conv_1_8_2_0_2_1_1 L0_N1019 L1_N212 3.8798345399e+05
R_Conv_1_8_2_0_2_2_0 L0_N1020 L1_N212 4.4022254443e+06
R_Conv_1_8_2_0_2_2_1 L0_N1021 L1_N212 1.5358515901e+05
*
R_Conv_1_8_2_1_0_0_0 L0_N904 L1_N213 1.2123709737e+05
R_Conv_1_8_2_1_0_0_1 L0_N905 L1_N213 1.0849154640e+05
R_Conv_1_8_2_1_0_1_0 L0_N906 L1_N213 2.0480317885e+05
R_Conv_1_8_2_1_0_1_1 L0_N907 L1_N213 1.6641635952e+05
R_Conv_1_8_2_1_0_2_0 L0_N908 L1_N213 1.1683261279e+06
R_Conv_1_8_2_1_0_2_1 L0_N909 L1_N213 1.1602008983e+05
R_Conv_1_8_2_1_1_0_0 L0_N960 L1_N213 1.2296662853e+05
R_Conv_1_8_2_1_1_0_1 L0_N961 L1_N213 1.6882235068e+05
R_Conv_1_8_2_1_1_1_0 L0_N962 L1_N213 1.0472083211e+05
R_Conv_1_8_2_1_1_1_1 L0_N963 L1_N213 2.1167619859e+05
R_Conv_1_8_2_1_1_2_0 L0_N964 L1_N213 1.3518319025e+05
R_Conv_1_8_2_1_1_2_1 L0_N965 L1_N213 1.4280846670e+05
R_Conv_1_8_2_1_2_0_0 L0_N1016 L1_N213 1.1620759255e+05
R_Conv_1_8_2_1_2_0_1 L0_N1017 L1_N213 1.6895116802e+05
R_Conv_1_8_2_1_2_1_0 L0_N1018 L1_N213 1.2455043512e+06
R_Conv_1_8_2_1_2_1_1 L0_N1019 L1_N213 1.1694022847e+05
R_Conv_1_8_2_1_2_2_0 L0_N1020 L1_N213 1.5663616684e+06
R_Conv_1_8_2_1_2_2_1 L0_N1021 L1_N213 2.1466641264e+05
*
R_Conv_1_8_3_0_0_0_0 L0_N908 L1_N214 3.0927915375e+05
R_Conv_1_8_3_0_0_0_1 L0_N909 L1_N214 3.6154472179e+05
R_Conv_1_8_3_0_0_1_0 L0_N910 L1_N214 1.2307612303e+05
R_Conv_1_8_3_0_0_1_1 L0_N911 L1_N214 1.3361401953e+06
R_Conv_1_8_3_0_0_2_0 L0_N912 L1_N214 1.1771240850e+06
R_Conv_1_8_3_0_0_2_1 L0_N913 L1_N214 1.1947062568e+05
R_Conv_1_8_3_0_1_0_0 L0_N964 L1_N214 3.4555602430e+05
R_Conv_1_8_3_0_1_0_1 L0_N965 L1_N214 1.2140655673e+05
R_Conv_1_8_3_0_1_1_0 L0_N966 L1_N214 2.0024008865e+05
R_Conv_1_8_3_0_1_1_1 L0_N967 L1_N214 1.3019124074e+05
R_Conv_1_8_3_0_1_2_0 L0_N968 L1_N214 1.1085089352e+05
R_Conv_1_8_3_0_1_2_1 L0_N969 L1_N214 2.5251460583e+05
R_Conv_1_8_3_0_2_0_0 L0_N1020 L1_N214 1.1040315248e+05
R_Conv_1_8_3_0_2_0_1 L0_N1021 L1_N214 1.2105931856e+05
R_Conv_1_8_3_0_2_1_0 L0_N1022 L1_N214 1.0186236681e+05
R_Conv_1_8_3_0_2_1_1 L0_N1023 L1_N214 3.8798345399e+05
R_Conv_1_8_3_0_2_2_0 L0_N1024 L1_N214 4.4022254443e+06
R_Conv_1_8_3_0_2_2_1 L0_N1025 L1_N214 1.5358515901e+05
*
R_Conv_1_8_3_1_0_0_0 L0_N908 L1_N215 1.2123709737e+05
R_Conv_1_8_3_1_0_0_1 L0_N909 L1_N215 1.0849154640e+05
R_Conv_1_8_3_1_0_1_0 L0_N910 L1_N215 2.0480317885e+05
R_Conv_1_8_3_1_0_1_1 L0_N911 L1_N215 1.6641635952e+05
R_Conv_1_8_3_1_0_2_0 L0_N912 L1_N215 1.1683261279e+06
R_Conv_1_8_3_1_0_2_1 L0_N913 L1_N215 1.1602008983e+05
R_Conv_1_8_3_1_1_0_0 L0_N964 L1_N215 1.2296662853e+05
R_Conv_1_8_3_1_1_0_1 L0_N965 L1_N215 1.6882235068e+05
R_Conv_1_8_3_1_1_1_0 L0_N966 L1_N215 1.0472083211e+05
R_Conv_1_8_3_1_1_1_1 L0_N967 L1_N215 2.1167619859e+05
R_Conv_1_8_3_1_1_2_0 L0_N968 L1_N215 1.3518319025e+05
R_Conv_1_8_3_1_1_2_1 L0_N969 L1_N215 1.4280846670e+05
R_Conv_1_8_3_1_2_0_0 L0_N1020 L1_N215 1.1620759255e+05
R_Conv_1_8_3_1_2_0_1 L0_N1021 L1_N215 1.6895116802e+05
R_Conv_1_8_3_1_2_1_0 L0_N1022 L1_N215 1.2455043512e+06
R_Conv_1_8_3_1_2_1_1 L0_N1023 L1_N215 1.1694022847e+05
R_Conv_1_8_3_1_2_2_0 L0_N1024 L1_N215 1.5663616684e+06
R_Conv_1_8_3_1_2_2_1 L0_N1025 L1_N215 2.1466641264e+05
*
R_Conv_1_8_4_0_0_0_0 L0_N912 L1_N216 3.0927915375e+05
R_Conv_1_8_4_0_0_0_1 L0_N913 L1_N216 3.6154472179e+05
R_Conv_1_8_4_0_0_1_0 L0_N914 L1_N216 1.2307612303e+05
R_Conv_1_8_4_0_0_1_1 L0_N915 L1_N216 1.3361401953e+06
R_Conv_1_8_4_0_0_2_0 L0_N916 L1_N216 1.1771240850e+06
R_Conv_1_8_4_0_0_2_1 L0_N917 L1_N216 1.1947062568e+05
R_Conv_1_8_4_0_1_0_0 L0_N968 L1_N216 3.4555602430e+05
R_Conv_1_8_4_0_1_0_1 L0_N969 L1_N216 1.2140655673e+05
R_Conv_1_8_4_0_1_1_0 L0_N970 L1_N216 2.0024008865e+05
R_Conv_1_8_4_0_1_1_1 L0_N971 L1_N216 1.3019124074e+05
R_Conv_1_8_4_0_1_2_0 L0_N972 L1_N216 1.1085089352e+05
R_Conv_1_8_4_0_1_2_1 L0_N973 L1_N216 2.5251460583e+05
R_Conv_1_8_4_0_2_0_0 L0_N1024 L1_N216 1.1040315248e+05
R_Conv_1_8_4_0_2_0_1 L0_N1025 L1_N216 1.2105931856e+05
R_Conv_1_8_4_0_2_1_0 L0_N1026 L1_N216 1.0186236681e+05
R_Conv_1_8_4_0_2_1_1 L0_N1027 L1_N216 3.8798345399e+05
R_Conv_1_8_4_0_2_2_0 L0_N1028 L1_N216 4.4022254443e+06
R_Conv_1_8_4_0_2_2_1 L0_N1029 L1_N216 1.5358515901e+05
*
R_Conv_1_8_4_1_0_0_0 L0_N912 L1_N217 1.2123709737e+05
R_Conv_1_8_4_1_0_0_1 L0_N913 L1_N217 1.0849154640e+05
R_Conv_1_8_4_1_0_1_0 L0_N914 L1_N217 2.0480317885e+05
R_Conv_1_8_4_1_0_1_1 L0_N915 L1_N217 1.6641635952e+05
R_Conv_1_8_4_1_0_2_0 L0_N916 L1_N217 1.1683261279e+06
R_Conv_1_8_4_1_0_2_1 L0_N917 L1_N217 1.1602008983e+05
R_Conv_1_8_4_1_1_0_0 L0_N968 L1_N217 1.2296662853e+05
R_Conv_1_8_4_1_1_0_1 L0_N969 L1_N217 1.6882235068e+05
R_Conv_1_8_4_1_1_1_0 L0_N970 L1_N217 1.0472083211e+05
R_Conv_1_8_4_1_1_1_1 L0_N971 L1_N217 2.1167619859e+05
R_Conv_1_8_4_1_1_2_0 L0_N972 L1_N217 1.3518319025e+05
R_Conv_1_8_4_1_1_2_1 L0_N973 L1_N217 1.4280846670e+05
R_Conv_1_8_4_1_2_0_0 L0_N1024 L1_N217 1.1620759255e+05
R_Conv_1_8_4_1_2_0_1 L0_N1025 L1_N217 1.6895116802e+05
R_Conv_1_8_4_1_2_1_0 L0_N1026 L1_N217 1.2455043512e+06
R_Conv_1_8_4_1_2_1_1 L0_N1027 L1_N217 1.1694022847e+05
R_Conv_1_8_4_1_2_2_0 L0_N1028 L1_N217 1.5663616684e+06
R_Conv_1_8_4_1_2_2_1 L0_N1029 L1_N217 2.1466641264e+05
*
R_Conv_1_8_5_0_0_0_0 L0_N916 L1_N218 3.0927915375e+05
R_Conv_1_8_5_0_0_0_1 L0_N917 L1_N218 3.6154472179e+05
R_Conv_1_8_5_0_0_1_0 L0_N918 L1_N218 1.2307612303e+05
R_Conv_1_8_5_0_0_1_1 L0_N919 L1_N218 1.3361401953e+06
R_Conv_1_8_5_0_0_2_0 L0_N920 L1_N218 1.1771240850e+06
R_Conv_1_8_5_0_0_2_1 L0_N921 L1_N218 1.1947062568e+05
R_Conv_1_8_5_0_1_0_0 L0_N972 L1_N218 3.4555602430e+05
R_Conv_1_8_5_0_1_0_1 L0_N973 L1_N218 1.2140655673e+05
R_Conv_1_8_5_0_1_1_0 L0_N974 L1_N218 2.0024008865e+05
R_Conv_1_8_5_0_1_1_1 L0_N975 L1_N218 1.3019124074e+05
R_Conv_1_8_5_0_1_2_0 L0_N976 L1_N218 1.1085089352e+05
R_Conv_1_8_5_0_1_2_1 L0_N977 L1_N218 2.5251460583e+05
R_Conv_1_8_5_0_2_0_0 L0_N1028 L1_N218 1.1040315248e+05
R_Conv_1_8_5_0_2_0_1 L0_N1029 L1_N218 1.2105931856e+05
R_Conv_1_8_5_0_2_1_0 L0_N1030 L1_N218 1.0186236681e+05
R_Conv_1_8_5_0_2_1_1 L0_N1031 L1_N218 3.8798345399e+05
R_Conv_1_8_5_0_2_2_0 L0_N1032 L1_N218 4.4022254443e+06
R_Conv_1_8_5_0_2_2_1 L0_N1033 L1_N218 1.5358515901e+05
*
R_Conv_1_8_5_1_0_0_0 L0_N916 L1_N219 1.2123709737e+05
R_Conv_1_8_5_1_0_0_1 L0_N917 L1_N219 1.0849154640e+05
R_Conv_1_8_5_1_0_1_0 L0_N918 L1_N219 2.0480317885e+05
R_Conv_1_8_5_1_0_1_1 L0_N919 L1_N219 1.6641635952e+05
R_Conv_1_8_5_1_0_2_0 L0_N920 L1_N219 1.1683261279e+06
R_Conv_1_8_5_1_0_2_1 L0_N921 L1_N219 1.1602008983e+05
R_Conv_1_8_5_1_1_0_0 L0_N972 L1_N219 1.2296662853e+05
R_Conv_1_8_5_1_1_0_1 L0_N973 L1_N219 1.6882235068e+05
R_Conv_1_8_5_1_1_1_0 L0_N974 L1_N219 1.0472083211e+05
R_Conv_1_8_5_1_1_1_1 L0_N975 L1_N219 2.1167619859e+05
R_Conv_1_8_5_1_1_2_0 L0_N976 L1_N219 1.3518319025e+05
R_Conv_1_8_5_1_1_2_1 L0_N977 L1_N219 1.4280846670e+05
R_Conv_1_8_5_1_2_0_0 L0_N1028 L1_N219 1.1620759255e+05
R_Conv_1_8_5_1_2_0_1 L0_N1029 L1_N219 1.6895116802e+05
R_Conv_1_8_5_1_2_1_0 L0_N1030 L1_N219 1.2455043512e+06
R_Conv_1_8_5_1_2_1_1 L0_N1031 L1_N219 1.1694022847e+05
R_Conv_1_8_5_1_2_2_0 L0_N1032 L1_N219 1.5663616684e+06
R_Conv_1_8_5_1_2_2_1 L0_N1033 L1_N219 2.1466641264e+05
*
R_Conv_1_8_6_0_0_0_0 L0_N920 L1_N220 3.0927915375e+05
R_Conv_1_8_6_0_0_0_1 L0_N921 L1_N220 3.6154472179e+05
R_Conv_1_8_6_0_0_1_0 L0_N922 L1_N220 1.2307612303e+05
R_Conv_1_8_6_0_0_1_1 L0_N923 L1_N220 1.3361401953e+06
R_Conv_1_8_6_0_0_2_0 L0_N924 L1_N220 1.1771240850e+06
R_Conv_1_8_6_0_0_2_1 L0_N925 L1_N220 1.1947062568e+05
R_Conv_1_8_6_0_1_0_0 L0_N976 L1_N220 3.4555602430e+05
R_Conv_1_8_6_0_1_0_1 L0_N977 L1_N220 1.2140655673e+05
R_Conv_1_8_6_0_1_1_0 L0_N978 L1_N220 2.0024008865e+05
R_Conv_1_8_6_0_1_1_1 L0_N979 L1_N220 1.3019124074e+05
R_Conv_1_8_6_0_1_2_0 L0_N980 L1_N220 1.1085089352e+05
R_Conv_1_8_6_0_1_2_1 L0_N981 L1_N220 2.5251460583e+05
R_Conv_1_8_6_0_2_0_0 L0_N1032 L1_N220 1.1040315248e+05
R_Conv_1_8_6_0_2_0_1 L0_N1033 L1_N220 1.2105931856e+05
R_Conv_1_8_6_0_2_1_0 L0_N1034 L1_N220 1.0186236681e+05
R_Conv_1_8_6_0_2_1_1 L0_N1035 L1_N220 3.8798345399e+05
R_Conv_1_8_6_0_2_2_0 L0_N1036 L1_N220 4.4022254443e+06
R_Conv_1_8_6_0_2_2_1 L0_N1037 L1_N220 1.5358515901e+05
*
R_Conv_1_8_6_1_0_0_0 L0_N920 L1_N221 1.2123709737e+05
R_Conv_1_8_6_1_0_0_1 L0_N921 L1_N221 1.0849154640e+05
R_Conv_1_8_6_1_0_1_0 L0_N922 L1_N221 2.0480317885e+05
R_Conv_1_8_6_1_0_1_1 L0_N923 L1_N221 1.6641635952e+05
R_Conv_1_8_6_1_0_2_0 L0_N924 L1_N221 1.1683261279e+06
R_Conv_1_8_6_1_0_2_1 L0_N925 L1_N221 1.1602008983e+05
R_Conv_1_8_6_1_1_0_0 L0_N976 L1_N221 1.2296662853e+05
R_Conv_1_8_6_1_1_0_1 L0_N977 L1_N221 1.6882235068e+05
R_Conv_1_8_6_1_1_1_0 L0_N978 L1_N221 1.0472083211e+05
R_Conv_1_8_6_1_1_1_1 L0_N979 L1_N221 2.1167619859e+05
R_Conv_1_8_6_1_1_2_0 L0_N980 L1_N221 1.3518319025e+05
R_Conv_1_8_6_1_1_2_1 L0_N981 L1_N221 1.4280846670e+05
R_Conv_1_8_6_1_2_0_0 L0_N1032 L1_N221 1.1620759255e+05
R_Conv_1_8_6_1_2_0_1 L0_N1033 L1_N221 1.6895116802e+05
R_Conv_1_8_6_1_2_1_0 L0_N1034 L1_N221 1.2455043512e+06
R_Conv_1_8_6_1_2_1_1 L0_N1035 L1_N221 1.1694022847e+05
R_Conv_1_8_6_1_2_2_0 L0_N1036 L1_N221 1.5663616684e+06
R_Conv_1_8_6_1_2_2_1 L0_N1037 L1_N221 2.1466641264e+05
*
R_Conv_1_8_7_0_0_0_0 L0_N924 L1_N222 3.0927915375e+05
R_Conv_1_8_7_0_0_0_1 L0_N925 L1_N222 3.6154472179e+05
R_Conv_1_8_7_0_0_1_0 L0_N926 L1_N222 1.2307612303e+05
R_Conv_1_8_7_0_0_1_1 L0_N927 L1_N222 1.3361401953e+06
R_Conv_1_8_7_0_0_2_0 L0_N928 L1_N222 1.1771240850e+06
R_Conv_1_8_7_0_0_2_1 L0_N929 L1_N222 1.1947062568e+05
R_Conv_1_8_7_0_1_0_0 L0_N980 L1_N222 3.4555602430e+05
R_Conv_1_8_7_0_1_0_1 L0_N981 L1_N222 1.2140655673e+05
R_Conv_1_8_7_0_1_1_0 L0_N982 L1_N222 2.0024008865e+05
R_Conv_1_8_7_0_1_1_1 L0_N983 L1_N222 1.3019124074e+05
R_Conv_1_8_7_0_1_2_0 L0_N984 L1_N222 1.1085089352e+05
R_Conv_1_8_7_0_1_2_1 L0_N985 L1_N222 2.5251460583e+05
R_Conv_1_8_7_0_2_0_0 L0_N1036 L1_N222 1.1040315248e+05
R_Conv_1_8_7_0_2_0_1 L0_N1037 L1_N222 1.2105931856e+05
R_Conv_1_8_7_0_2_1_0 L0_N1038 L1_N222 1.0186236681e+05
R_Conv_1_8_7_0_2_1_1 L0_N1039 L1_N222 3.8798345399e+05
R_Conv_1_8_7_0_2_2_0 L0_N1040 L1_N222 4.4022254443e+06
R_Conv_1_8_7_0_2_2_1 L0_N1041 L1_N222 1.5358515901e+05
*
R_Conv_1_8_7_1_0_0_0 L0_N924 L1_N223 1.2123709737e+05
R_Conv_1_8_7_1_0_0_1 L0_N925 L1_N223 1.0849154640e+05
R_Conv_1_8_7_1_0_1_0 L0_N926 L1_N223 2.0480317885e+05
R_Conv_1_8_7_1_0_1_1 L0_N927 L1_N223 1.6641635952e+05
R_Conv_1_8_7_1_0_2_0 L0_N928 L1_N223 1.1683261279e+06
R_Conv_1_8_7_1_0_2_1 L0_N929 L1_N223 1.1602008983e+05
R_Conv_1_8_7_1_1_0_0 L0_N980 L1_N223 1.2296662853e+05
R_Conv_1_8_7_1_1_0_1 L0_N981 L1_N223 1.6882235068e+05
R_Conv_1_8_7_1_1_1_0 L0_N982 L1_N223 1.0472083211e+05
R_Conv_1_8_7_1_1_1_1 L0_N983 L1_N223 2.1167619859e+05
R_Conv_1_8_7_1_1_2_0 L0_N984 L1_N223 1.3518319025e+05
R_Conv_1_8_7_1_1_2_1 L0_N985 L1_N223 1.4280846670e+05
R_Conv_1_8_7_1_2_0_0 L0_N1036 L1_N223 1.1620759255e+05
R_Conv_1_8_7_1_2_0_1 L0_N1037 L1_N223 1.6895116802e+05
R_Conv_1_8_7_1_2_1_0 L0_N1038 L1_N223 1.2455043512e+06
R_Conv_1_8_7_1_2_1_1 L0_N1039 L1_N223 1.1694022847e+05
R_Conv_1_8_7_1_2_2_0 L0_N1040 L1_N223 1.5663616684e+06
R_Conv_1_8_7_1_2_2_1 L0_N1041 L1_N223 2.1466641264e+05
*
R_Conv_1_8_8_0_0_0_0 L0_N928 L1_N224 3.0927915375e+05
R_Conv_1_8_8_0_0_0_1 L0_N929 L1_N224 3.6154472179e+05
R_Conv_1_8_8_0_0_1_0 L0_N930 L1_N224 1.2307612303e+05
R_Conv_1_8_8_0_0_1_1 L0_N931 L1_N224 1.3361401953e+06
R_Conv_1_8_8_0_0_2_0 L0_N932 L1_N224 1.1771240850e+06
R_Conv_1_8_8_0_0_2_1 L0_N933 L1_N224 1.1947062568e+05
R_Conv_1_8_8_0_1_0_0 L0_N984 L1_N224 3.4555602430e+05
R_Conv_1_8_8_0_1_0_1 L0_N985 L1_N224 1.2140655673e+05
R_Conv_1_8_8_0_1_1_0 L0_N986 L1_N224 2.0024008865e+05
R_Conv_1_8_8_0_1_1_1 L0_N987 L1_N224 1.3019124074e+05
R_Conv_1_8_8_0_1_2_0 L0_N988 L1_N224 1.1085089352e+05
R_Conv_1_8_8_0_1_2_1 L0_N989 L1_N224 2.5251460583e+05
R_Conv_1_8_8_0_2_0_0 L0_N1040 L1_N224 1.1040315248e+05
R_Conv_1_8_8_0_2_0_1 L0_N1041 L1_N224 1.2105931856e+05
R_Conv_1_8_8_0_2_1_0 L0_N1042 L1_N224 1.0186236681e+05
R_Conv_1_8_8_0_2_1_1 L0_N1043 L1_N224 3.8798345399e+05
R_Conv_1_8_8_0_2_2_0 L0_N1044 L1_N224 4.4022254443e+06
R_Conv_1_8_8_0_2_2_1 L0_N1045 L1_N224 1.5358515901e+05
*
R_Conv_1_8_8_1_0_0_0 L0_N928 L1_N225 1.2123709737e+05
R_Conv_1_8_8_1_0_0_1 L0_N929 L1_N225 1.0849154640e+05
R_Conv_1_8_8_1_0_1_0 L0_N930 L1_N225 2.0480317885e+05
R_Conv_1_8_8_1_0_1_1 L0_N931 L1_N225 1.6641635952e+05
R_Conv_1_8_8_1_0_2_0 L0_N932 L1_N225 1.1683261279e+06
R_Conv_1_8_8_1_0_2_1 L0_N933 L1_N225 1.1602008983e+05
R_Conv_1_8_8_1_1_0_0 L0_N984 L1_N225 1.2296662853e+05
R_Conv_1_8_8_1_1_0_1 L0_N985 L1_N225 1.6882235068e+05
R_Conv_1_8_8_1_1_1_0 L0_N986 L1_N225 1.0472083211e+05
R_Conv_1_8_8_1_1_1_1 L0_N987 L1_N225 2.1167619859e+05
R_Conv_1_8_8_1_1_2_0 L0_N988 L1_N225 1.3518319025e+05
R_Conv_1_8_8_1_1_2_1 L0_N989 L1_N225 1.4280846670e+05
R_Conv_1_8_8_1_2_0_0 L0_N1040 L1_N225 1.1620759255e+05
R_Conv_1_8_8_1_2_0_1 L0_N1041 L1_N225 1.6895116802e+05
R_Conv_1_8_8_1_2_1_0 L0_N1042 L1_N225 1.2455043512e+06
R_Conv_1_8_8_1_2_1_1 L0_N1043 L1_N225 1.1694022847e+05
R_Conv_1_8_8_1_2_2_0 L0_N1044 L1_N225 1.5663616684e+06
R_Conv_1_8_8_1_2_2_1 L0_N1045 L1_N225 2.1466641264e+05
*
R_Conv_1_8_9_0_0_0_0 L0_N932 L1_N226 3.0927915375e+05
R_Conv_1_8_9_0_0_0_1 L0_N933 L1_N226 3.6154472179e+05
R_Conv_1_8_9_0_0_1_0 L0_N934 L1_N226 1.2307612303e+05
R_Conv_1_8_9_0_0_1_1 L0_N935 L1_N226 1.3361401953e+06
R_Conv_1_8_9_0_0_2_0 L0_N936 L1_N226 1.1771240850e+06
R_Conv_1_8_9_0_0_2_1 L0_N937 L1_N226 1.1947062568e+05
R_Conv_1_8_9_0_1_0_0 L0_N988 L1_N226 3.4555602430e+05
R_Conv_1_8_9_0_1_0_1 L0_N989 L1_N226 1.2140655673e+05
R_Conv_1_8_9_0_1_1_0 L0_N990 L1_N226 2.0024008865e+05
R_Conv_1_8_9_0_1_1_1 L0_N991 L1_N226 1.3019124074e+05
R_Conv_1_8_9_0_1_2_0 L0_N992 L1_N226 1.1085089352e+05
R_Conv_1_8_9_0_1_2_1 L0_N993 L1_N226 2.5251460583e+05
R_Conv_1_8_9_0_2_0_0 L0_N1044 L1_N226 1.1040315248e+05
R_Conv_1_8_9_0_2_0_1 L0_N1045 L1_N226 1.2105931856e+05
R_Conv_1_8_9_0_2_1_0 L0_N1046 L1_N226 1.0186236681e+05
R_Conv_1_8_9_0_2_1_1 L0_N1047 L1_N226 3.8798345399e+05
R_Conv_1_8_9_0_2_2_0 L0_N1048 L1_N226 4.4022254443e+06
R_Conv_1_8_9_0_2_2_1 L0_N1049 L1_N226 1.5358515901e+05
*
R_Conv_1_8_9_1_0_0_0 L0_N932 L1_N227 1.2123709737e+05
R_Conv_1_8_9_1_0_0_1 L0_N933 L1_N227 1.0849154640e+05
R_Conv_1_8_9_1_0_1_0 L0_N934 L1_N227 2.0480317885e+05
R_Conv_1_8_9_1_0_1_1 L0_N935 L1_N227 1.6641635952e+05
R_Conv_1_8_9_1_0_2_0 L0_N936 L1_N227 1.1683261279e+06
R_Conv_1_8_9_1_0_2_1 L0_N937 L1_N227 1.1602008983e+05
R_Conv_1_8_9_1_1_0_0 L0_N988 L1_N227 1.2296662853e+05
R_Conv_1_8_9_1_1_0_1 L0_N989 L1_N227 1.6882235068e+05
R_Conv_1_8_9_1_1_1_0 L0_N990 L1_N227 1.0472083211e+05
R_Conv_1_8_9_1_1_1_1 L0_N991 L1_N227 2.1167619859e+05
R_Conv_1_8_9_1_1_2_0 L0_N992 L1_N227 1.3518319025e+05
R_Conv_1_8_9_1_1_2_1 L0_N993 L1_N227 1.4280846670e+05
R_Conv_1_8_9_1_2_0_0 L0_N1044 L1_N227 1.1620759255e+05
R_Conv_1_8_9_1_2_0_1 L0_N1045 L1_N227 1.6895116802e+05
R_Conv_1_8_9_1_2_1_0 L0_N1046 L1_N227 1.2455043512e+06
R_Conv_1_8_9_1_2_1_1 L0_N1047 L1_N227 1.1694022847e+05
R_Conv_1_8_9_1_2_2_0 L0_N1048 L1_N227 1.5663616684e+06
R_Conv_1_8_9_1_2_2_1 L0_N1049 L1_N227 2.1466641264e+05
*
R_Conv_1_8_10_0_0_0_0 L0_N936 L1_N228 3.0927915375e+05
R_Conv_1_8_10_0_0_0_1 L0_N937 L1_N228 3.6154472179e+05
R_Conv_1_8_10_0_0_1_0 L0_N938 L1_N228 1.2307612303e+05
R_Conv_1_8_10_0_0_1_1 L0_N939 L1_N228 1.3361401953e+06
R_Conv_1_8_10_0_0_2_0 L0_N940 L1_N228 1.1771240850e+06
R_Conv_1_8_10_0_0_2_1 L0_N941 L1_N228 1.1947062568e+05
R_Conv_1_8_10_0_1_0_0 L0_N992 L1_N228 3.4555602430e+05
R_Conv_1_8_10_0_1_0_1 L0_N993 L1_N228 1.2140655673e+05
R_Conv_1_8_10_0_1_1_0 L0_N994 L1_N228 2.0024008865e+05
R_Conv_1_8_10_0_1_1_1 L0_N995 L1_N228 1.3019124074e+05
R_Conv_1_8_10_0_1_2_0 L0_N996 L1_N228 1.1085089352e+05
R_Conv_1_8_10_0_1_2_1 L0_N997 L1_N228 2.5251460583e+05
R_Conv_1_8_10_0_2_0_0 L0_N1048 L1_N228 1.1040315248e+05
R_Conv_1_8_10_0_2_0_1 L0_N1049 L1_N228 1.2105931856e+05
R_Conv_1_8_10_0_2_1_0 L0_N1050 L1_N228 1.0186236681e+05
R_Conv_1_8_10_0_2_1_1 L0_N1051 L1_N228 3.8798345399e+05
R_Conv_1_8_10_0_2_2_0 L0_N1052 L1_N228 4.4022254443e+06
R_Conv_1_8_10_0_2_2_1 L0_N1053 L1_N228 1.5358515901e+05
*
R_Conv_1_8_10_1_0_0_0 L0_N936 L1_N229 1.2123709737e+05
R_Conv_1_8_10_1_0_0_1 L0_N937 L1_N229 1.0849154640e+05
R_Conv_1_8_10_1_0_1_0 L0_N938 L1_N229 2.0480317885e+05
R_Conv_1_8_10_1_0_1_1 L0_N939 L1_N229 1.6641635952e+05
R_Conv_1_8_10_1_0_2_0 L0_N940 L1_N229 1.1683261279e+06
R_Conv_1_8_10_1_0_2_1 L0_N941 L1_N229 1.1602008983e+05
R_Conv_1_8_10_1_1_0_0 L0_N992 L1_N229 1.2296662853e+05
R_Conv_1_8_10_1_1_0_1 L0_N993 L1_N229 1.6882235068e+05
R_Conv_1_8_10_1_1_1_0 L0_N994 L1_N229 1.0472083211e+05
R_Conv_1_8_10_1_1_1_1 L0_N995 L1_N229 2.1167619859e+05
R_Conv_1_8_10_1_1_2_0 L0_N996 L1_N229 1.3518319025e+05
R_Conv_1_8_10_1_1_2_1 L0_N997 L1_N229 1.4280846670e+05
R_Conv_1_8_10_1_2_0_0 L0_N1048 L1_N229 1.1620759255e+05
R_Conv_1_8_10_1_2_0_1 L0_N1049 L1_N229 1.6895116802e+05
R_Conv_1_8_10_1_2_1_0 L0_N1050 L1_N229 1.2455043512e+06
R_Conv_1_8_10_1_2_1_1 L0_N1051 L1_N229 1.1694022847e+05
R_Conv_1_8_10_1_2_2_0 L0_N1052 L1_N229 1.5663616684e+06
R_Conv_1_8_10_1_2_2_1 L0_N1053 L1_N229 2.1466641264e+05
*
R_Conv_1_8_11_0_0_0_0 L0_N940 L1_N230 3.0927915375e+05
R_Conv_1_8_11_0_0_0_1 L0_N941 L1_N230 3.6154472179e+05
R_Conv_1_8_11_0_0_1_0 L0_N942 L1_N230 1.2307612303e+05
R_Conv_1_8_11_0_0_1_1 L0_N943 L1_N230 1.3361401953e+06
R_Conv_1_8_11_0_0_2_0 L0_N944 L1_N230 1.1771240850e+06
R_Conv_1_8_11_0_0_2_1 L0_N945 L1_N230 1.1947062568e+05
R_Conv_1_8_11_0_1_0_0 L0_N996 L1_N230 3.4555602430e+05
R_Conv_1_8_11_0_1_0_1 L0_N997 L1_N230 1.2140655673e+05
R_Conv_1_8_11_0_1_1_0 L0_N998 L1_N230 2.0024008865e+05
R_Conv_1_8_11_0_1_1_1 L0_N999 L1_N230 1.3019124074e+05
R_Conv_1_8_11_0_1_2_0 L0_N1000 L1_N230 1.1085089352e+05
R_Conv_1_8_11_0_1_2_1 L0_N1001 L1_N230 2.5251460583e+05
R_Conv_1_8_11_0_2_0_0 L0_N1052 L1_N230 1.1040315248e+05
R_Conv_1_8_11_0_2_0_1 L0_N1053 L1_N230 1.2105931856e+05
R_Conv_1_8_11_0_2_1_0 L0_N1054 L1_N230 1.0186236681e+05
R_Conv_1_8_11_0_2_1_1 L0_N1055 L1_N230 3.8798345399e+05
R_Conv_1_8_11_0_2_2_0 L0_N1056 L1_N230 4.4022254443e+06
R_Conv_1_8_11_0_2_2_1 L0_N1057 L1_N230 1.5358515901e+05
*
R_Conv_1_8_11_1_0_0_0 L0_N940 L1_N231 1.2123709737e+05
R_Conv_1_8_11_1_0_0_1 L0_N941 L1_N231 1.0849154640e+05
R_Conv_1_8_11_1_0_1_0 L0_N942 L1_N231 2.0480317885e+05
R_Conv_1_8_11_1_0_1_1 L0_N943 L1_N231 1.6641635952e+05
R_Conv_1_8_11_1_0_2_0 L0_N944 L1_N231 1.1683261279e+06
R_Conv_1_8_11_1_0_2_1 L0_N945 L1_N231 1.1602008983e+05
R_Conv_1_8_11_1_1_0_0 L0_N996 L1_N231 1.2296662853e+05
R_Conv_1_8_11_1_1_0_1 L0_N997 L1_N231 1.6882235068e+05
R_Conv_1_8_11_1_1_1_0 L0_N998 L1_N231 1.0472083211e+05
R_Conv_1_8_11_1_1_1_1 L0_N999 L1_N231 2.1167619859e+05
R_Conv_1_8_11_1_1_2_0 L0_N1000 L1_N231 1.3518319025e+05
R_Conv_1_8_11_1_1_2_1 L0_N1001 L1_N231 1.4280846670e+05
R_Conv_1_8_11_1_2_0_0 L0_N1052 L1_N231 1.1620759255e+05
R_Conv_1_8_11_1_2_0_1 L0_N1053 L1_N231 1.6895116802e+05
R_Conv_1_8_11_1_2_1_0 L0_N1054 L1_N231 1.2455043512e+06
R_Conv_1_8_11_1_2_1_1 L0_N1055 L1_N231 1.1694022847e+05
R_Conv_1_8_11_1_2_2_0 L0_N1056 L1_N231 1.5663616684e+06
R_Conv_1_8_11_1_2_2_1 L0_N1057 L1_N231 2.1466641264e+05
*
R_Conv_1_8_12_0_0_0_0 L0_N944 L1_N232 3.0927915375e+05
R_Conv_1_8_12_0_0_0_1 L0_N945 L1_N232 3.6154472179e+05
R_Conv_1_8_12_0_0_1_0 L0_N946 L1_N232 1.2307612303e+05
R_Conv_1_8_12_0_0_1_1 L0_N947 L1_N232 1.3361401953e+06
R_Conv_1_8_12_0_0_2_0 L0_N948 L1_N232 1.1771240850e+06
R_Conv_1_8_12_0_0_2_1 L0_N949 L1_N232 1.1947062568e+05
R_Conv_1_8_12_0_1_0_0 L0_N1000 L1_N232 3.4555602430e+05
R_Conv_1_8_12_0_1_0_1 L0_N1001 L1_N232 1.2140655673e+05
R_Conv_1_8_12_0_1_1_0 L0_N1002 L1_N232 2.0024008865e+05
R_Conv_1_8_12_0_1_1_1 L0_N1003 L1_N232 1.3019124074e+05
R_Conv_1_8_12_0_1_2_0 L0_N1004 L1_N232 1.1085089352e+05
R_Conv_1_8_12_0_1_2_1 L0_N1005 L1_N232 2.5251460583e+05
R_Conv_1_8_12_0_2_0_0 L0_N1056 L1_N232 1.1040315248e+05
R_Conv_1_8_12_0_2_0_1 L0_N1057 L1_N232 1.2105931856e+05
R_Conv_1_8_12_0_2_1_0 L0_N1058 L1_N232 1.0186236681e+05
R_Conv_1_8_12_0_2_1_1 L0_N1059 L1_N232 3.8798345399e+05
R_Conv_1_8_12_0_2_2_0 L0_N1060 L1_N232 4.4022254443e+06
R_Conv_1_8_12_0_2_2_1 L0_N1061 L1_N232 1.5358515901e+05
*
R_Conv_1_8_12_1_0_0_0 L0_N944 L1_N233 1.2123709737e+05
R_Conv_1_8_12_1_0_0_1 L0_N945 L1_N233 1.0849154640e+05
R_Conv_1_8_12_1_0_1_0 L0_N946 L1_N233 2.0480317885e+05
R_Conv_1_8_12_1_0_1_1 L0_N947 L1_N233 1.6641635952e+05
R_Conv_1_8_12_1_0_2_0 L0_N948 L1_N233 1.1683261279e+06
R_Conv_1_8_12_1_0_2_1 L0_N949 L1_N233 1.1602008983e+05
R_Conv_1_8_12_1_1_0_0 L0_N1000 L1_N233 1.2296662853e+05
R_Conv_1_8_12_1_1_0_1 L0_N1001 L1_N233 1.6882235068e+05
R_Conv_1_8_12_1_1_1_0 L0_N1002 L1_N233 1.0472083211e+05
R_Conv_1_8_12_1_1_1_1 L0_N1003 L1_N233 2.1167619859e+05
R_Conv_1_8_12_1_1_2_0 L0_N1004 L1_N233 1.3518319025e+05
R_Conv_1_8_12_1_1_2_1 L0_N1005 L1_N233 1.4280846670e+05
R_Conv_1_8_12_1_2_0_0 L0_N1056 L1_N233 1.1620759255e+05
R_Conv_1_8_12_1_2_0_1 L0_N1057 L1_N233 1.6895116802e+05
R_Conv_1_8_12_1_2_1_0 L0_N1058 L1_N233 1.2455043512e+06
R_Conv_1_8_12_1_2_1_1 L0_N1059 L1_N233 1.1694022847e+05
R_Conv_1_8_12_1_2_2_0 L0_N1060 L1_N233 1.5663616684e+06
R_Conv_1_8_12_1_2_2_1 L0_N1061 L1_N233 2.1466641264e+05
*
R_Conv_1_9_0_0_0_0_0 L0_N1008 L1_N234 3.0927915375e+05
R_Conv_1_9_0_0_0_0_1 L0_N1009 L1_N234 3.6154472179e+05
R_Conv_1_9_0_0_0_1_0 L0_N1010 L1_N234 1.2307612303e+05
R_Conv_1_9_0_0_0_1_1 L0_N1011 L1_N234 1.3361401953e+06
R_Conv_1_9_0_0_0_2_0 L0_N1012 L1_N234 1.1771240850e+06
R_Conv_1_9_0_0_0_2_1 L0_N1013 L1_N234 1.1947062568e+05
R_Conv_1_9_0_0_1_0_0 L0_N1064 L1_N234 3.4555602430e+05
R_Conv_1_9_0_0_1_0_1 L0_N1065 L1_N234 1.2140655673e+05
R_Conv_1_9_0_0_1_1_0 L0_N1066 L1_N234 2.0024008865e+05
R_Conv_1_9_0_0_1_1_1 L0_N1067 L1_N234 1.3019124074e+05
R_Conv_1_9_0_0_1_2_0 L0_N1068 L1_N234 1.1085089352e+05
R_Conv_1_9_0_0_1_2_1 L0_N1069 L1_N234 2.5251460583e+05
R_Conv_1_9_0_0_2_0_0 L0_N1120 L1_N234 1.1040315248e+05
R_Conv_1_9_0_0_2_0_1 L0_N1121 L1_N234 1.2105931856e+05
R_Conv_1_9_0_0_2_1_0 L0_N1122 L1_N234 1.0186236681e+05
R_Conv_1_9_0_0_2_1_1 L0_N1123 L1_N234 3.8798345399e+05
R_Conv_1_9_0_0_2_2_0 L0_N1124 L1_N234 4.4022254443e+06
R_Conv_1_9_0_0_2_2_1 L0_N1125 L1_N234 1.5358515901e+05
*
R_Conv_1_9_0_1_0_0_0 L0_N1008 L1_N235 1.2123709737e+05
R_Conv_1_9_0_1_0_0_1 L0_N1009 L1_N235 1.0849154640e+05
R_Conv_1_9_0_1_0_1_0 L0_N1010 L1_N235 2.0480317885e+05
R_Conv_1_9_0_1_0_1_1 L0_N1011 L1_N235 1.6641635952e+05
R_Conv_1_9_0_1_0_2_0 L0_N1012 L1_N235 1.1683261279e+06
R_Conv_1_9_0_1_0_2_1 L0_N1013 L1_N235 1.1602008983e+05
R_Conv_1_9_0_1_1_0_0 L0_N1064 L1_N235 1.2296662853e+05
R_Conv_1_9_0_1_1_0_1 L0_N1065 L1_N235 1.6882235068e+05
R_Conv_1_9_0_1_1_1_0 L0_N1066 L1_N235 1.0472083211e+05
R_Conv_1_9_0_1_1_1_1 L0_N1067 L1_N235 2.1167619859e+05
R_Conv_1_9_0_1_1_2_0 L0_N1068 L1_N235 1.3518319025e+05
R_Conv_1_9_0_1_1_2_1 L0_N1069 L1_N235 1.4280846670e+05
R_Conv_1_9_0_1_2_0_0 L0_N1120 L1_N235 1.1620759255e+05
R_Conv_1_9_0_1_2_0_1 L0_N1121 L1_N235 1.6895116802e+05
R_Conv_1_9_0_1_2_1_0 L0_N1122 L1_N235 1.2455043512e+06
R_Conv_1_9_0_1_2_1_1 L0_N1123 L1_N235 1.1694022847e+05
R_Conv_1_9_0_1_2_2_0 L0_N1124 L1_N235 1.5663616684e+06
R_Conv_1_9_0_1_2_2_1 L0_N1125 L1_N235 2.1466641264e+05
*
R_Conv_1_9_1_0_0_0_0 L0_N1012 L1_N236 3.0927915375e+05
R_Conv_1_9_1_0_0_0_1 L0_N1013 L1_N236 3.6154472179e+05
R_Conv_1_9_1_0_0_1_0 L0_N1014 L1_N236 1.2307612303e+05
R_Conv_1_9_1_0_0_1_1 L0_N1015 L1_N236 1.3361401953e+06
R_Conv_1_9_1_0_0_2_0 L0_N1016 L1_N236 1.1771240850e+06
R_Conv_1_9_1_0_0_2_1 L0_N1017 L1_N236 1.1947062568e+05
R_Conv_1_9_1_0_1_0_0 L0_N1068 L1_N236 3.4555602430e+05
R_Conv_1_9_1_0_1_0_1 L0_N1069 L1_N236 1.2140655673e+05
R_Conv_1_9_1_0_1_1_0 L0_N1070 L1_N236 2.0024008865e+05
R_Conv_1_9_1_0_1_1_1 L0_N1071 L1_N236 1.3019124074e+05
R_Conv_1_9_1_0_1_2_0 L0_N1072 L1_N236 1.1085089352e+05
R_Conv_1_9_1_0_1_2_1 L0_N1073 L1_N236 2.5251460583e+05
R_Conv_1_9_1_0_2_0_0 L0_N1124 L1_N236 1.1040315248e+05
R_Conv_1_9_1_0_2_0_1 L0_N1125 L1_N236 1.2105931856e+05
R_Conv_1_9_1_0_2_1_0 L0_N1126 L1_N236 1.0186236681e+05
R_Conv_1_9_1_0_2_1_1 L0_N1127 L1_N236 3.8798345399e+05
R_Conv_1_9_1_0_2_2_0 L0_N1128 L1_N236 4.4022254443e+06
R_Conv_1_9_1_0_2_2_1 L0_N1129 L1_N236 1.5358515901e+05
*
R_Conv_1_9_1_1_0_0_0 L0_N1012 L1_N237 1.2123709737e+05
R_Conv_1_9_1_1_0_0_1 L0_N1013 L1_N237 1.0849154640e+05
R_Conv_1_9_1_1_0_1_0 L0_N1014 L1_N237 2.0480317885e+05
R_Conv_1_9_1_1_0_1_1 L0_N1015 L1_N237 1.6641635952e+05
R_Conv_1_9_1_1_0_2_0 L0_N1016 L1_N237 1.1683261279e+06
R_Conv_1_9_1_1_0_2_1 L0_N1017 L1_N237 1.1602008983e+05
R_Conv_1_9_1_1_1_0_0 L0_N1068 L1_N237 1.2296662853e+05
R_Conv_1_9_1_1_1_0_1 L0_N1069 L1_N237 1.6882235068e+05
R_Conv_1_9_1_1_1_1_0 L0_N1070 L1_N237 1.0472083211e+05
R_Conv_1_9_1_1_1_1_1 L0_N1071 L1_N237 2.1167619859e+05
R_Conv_1_9_1_1_1_2_0 L0_N1072 L1_N237 1.3518319025e+05
R_Conv_1_9_1_1_1_2_1 L0_N1073 L1_N237 1.4280846670e+05
R_Conv_1_9_1_1_2_0_0 L0_N1124 L1_N237 1.1620759255e+05
R_Conv_1_9_1_1_2_0_1 L0_N1125 L1_N237 1.6895116802e+05
R_Conv_1_9_1_1_2_1_0 L0_N1126 L1_N237 1.2455043512e+06
R_Conv_1_9_1_1_2_1_1 L0_N1127 L1_N237 1.1694022847e+05
R_Conv_1_9_1_1_2_2_0 L0_N1128 L1_N237 1.5663616684e+06
R_Conv_1_9_1_1_2_2_1 L0_N1129 L1_N237 2.1466641264e+05
*
R_Conv_1_9_2_0_0_0_0 L0_N1016 L1_N238 3.0927915375e+05
R_Conv_1_9_2_0_0_0_1 L0_N1017 L1_N238 3.6154472179e+05
R_Conv_1_9_2_0_0_1_0 L0_N1018 L1_N238 1.2307612303e+05
R_Conv_1_9_2_0_0_1_1 L0_N1019 L1_N238 1.3361401953e+06
R_Conv_1_9_2_0_0_2_0 L0_N1020 L1_N238 1.1771240850e+06
R_Conv_1_9_2_0_0_2_1 L0_N1021 L1_N238 1.1947062568e+05
R_Conv_1_9_2_0_1_0_0 L0_N1072 L1_N238 3.4555602430e+05
R_Conv_1_9_2_0_1_0_1 L0_N1073 L1_N238 1.2140655673e+05
R_Conv_1_9_2_0_1_1_0 L0_N1074 L1_N238 2.0024008865e+05
R_Conv_1_9_2_0_1_1_1 L0_N1075 L1_N238 1.3019124074e+05
R_Conv_1_9_2_0_1_2_0 L0_N1076 L1_N238 1.1085089352e+05
R_Conv_1_9_2_0_1_2_1 L0_N1077 L1_N238 2.5251460583e+05
R_Conv_1_9_2_0_2_0_0 L0_N1128 L1_N238 1.1040315248e+05
R_Conv_1_9_2_0_2_0_1 L0_N1129 L1_N238 1.2105931856e+05
R_Conv_1_9_2_0_2_1_0 L0_N1130 L1_N238 1.0186236681e+05
R_Conv_1_9_2_0_2_1_1 L0_N1131 L1_N238 3.8798345399e+05
R_Conv_1_9_2_0_2_2_0 L0_N1132 L1_N238 4.4022254443e+06
R_Conv_1_9_2_0_2_2_1 L0_N1133 L1_N238 1.5358515901e+05
*
R_Conv_1_9_2_1_0_0_0 L0_N1016 L1_N239 1.2123709737e+05
R_Conv_1_9_2_1_0_0_1 L0_N1017 L1_N239 1.0849154640e+05
R_Conv_1_9_2_1_0_1_0 L0_N1018 L1_N239 2.0480317885e+05
R_Conv_1_9_2_1_0_1_1 L0_N1019 L1_N239 1.6641635952e+05
R_Conv_1_9_2_1_0_2_0 L0_N1020 L1_N239 1.1683261279e+06
R_Conv_1_9_2_1_0_2_1 L0_N1021 L1_N239 1.1602008983e+05
R_Conv_1_9_2_1_1_0_0 L0_N1072 L1_N239 1.2296662853e+05
R_Conv_1_9_2_1_1_0_1 L0_N1073 L1_N239 1.6882235068e+05
R_Conv_1_9_2_1_1_1_0 L0_N1074 L1_N239 1.0472083211e+05
R_Conv_1_9_2_1_1_1_1 L0_N1075 L1_N239 2.1167619859e+05
R_Conv_1_9_2_1_1_2_0 L0_N1076 L1_N239 1.3518319025e+05
R_Conv_1_9_2_1_1_2_1 L0_N1077 L1_N239 1.4280846670e+05
R_Conv_1_9_2_1_2_0_0 L0_N1128 L1_N239 1.1620759255e+05
R_Conv_1_9_2_1_2_0_1 L0_N1129 L1_N239 1.6895116802e+05
R_Conv_1_9_2_1_2_1_0 L0_N1130 L1_N239 1.2455043512e+06
R_Conv_1_9_2_1_2_1_1 L0_N1131 L1_N239 1.1694022847e+05
R_Conv_1_9_2_1_2_2_0 L0_N1132 L1_N239 1.5663616684e+06
R_Conv_1_9_2_1_2_2_1 L0_N1133 L1_N239 2.1466641264e+05
*
R_Conv_1_9_3_0_0_0_0 L0_N1020 L1_N240 3.0927915375e+05
R_Conv_1_9_3_0_0_0_1 L0_N1021 L1_N240 3.6154472179e+05
R_Conv_1_9_3_0_0_1_0 L0_N1022 L1_N240 1.2307612303e+05
R_Conv_1_9_3_0_0_1_1 L0_N1023 L1_N240 1.3361401953e+06
R_Conv_1_9_3_0_0_2_0 L0_N1024 L1_N240 1.1771240850e+06
R_Conv_1_9_3_0_0_2_1 L0_N1025 L1_N240 1.1947062568e+05
R_Conv_1_9_3_0_1_0_0 L0_N1076 L1_N240 3.4555602430e+05
R_Conv_1_9_3_0_1_0_1 L0_N1077 L1_N240 1.2140655673e+05
R_Conv_1_9_3_0_1_1_0 L0_N1078 L1_N240 2.0024008865e+05
R_Conv_1_9_3_0_1_1_1 L0_N1079 L1_N240 1.3019124074e+05
R_Conv_1_9_3_0_1_2_0 L0_N1080 L1_N240 1.1085089352e+05
R_Conv_1_9_3_0_1_2_1 L0_N1081 L1_N240 2.5251460583e+05
R_Conv_1_9_3_0_2_0_0 L0_N1132 L1_N240 1.1040315248e+05
R_Conv_1_9_3_0_2_0_1 L0_N1133 L1_N240 1.2105931856e+05
R_Conv_1_9_3_0_2_1_0 L0_N1134 L1_N240 1.0186236681e+05
R_Conv_1_9_3_0_2_1_1 L0_N1135 L1_N240 3.8798345399e+05
R_Conv_1_9_3_0_2_2_0 L0_N1136 L1_N240 4.4022254443e+06
R_Conv_1_9_3_0_2_2_1 L0_N1137 L1_N240 1.5358515901e+05
*
R_Conv_1_9_3_1_0_0_0 L0_N1020 L1_N241 1.2123709737e+05
R_Conv_1_9_3_1_0_0_1 L0_N1021 L1_N241 1.0849154640e+05
R_Conv_1_9_3_1_0_1_0 L0_N1022 L1_N241 2.0480317885e+05
R_Conv_1_9_3_1_0_1_1 L0_N1023 L1_N241 1.6641635952e+05
R_Conv_1_9_3_1_0_2_0 L0_N1024 L1_N241 1.1683261279e+06
R_Conv_1_9_3_1_0_2_1 L0_N1025 L1_N241 1.1602008983e+05
R_Conv_1_9_3_1_1_0_0 L0_N1076 L1_N241 1.2296662853e+05
R_Conv_1_9_3_1_1_0_1 L0_N1077 L1_N241 1.6882235068e+05
R_Conv_1_9_3_1_1_1_0 L0_N1078 L1_N241 1.0472083211e+05
R_Conv_1_9_3_1_1_1_1 L0_N1079 L1_N241 2.1167619859e+05
R_Conv_1_9_3_1_1_2_0 L0_N1080 L1_N241 1.3518319025e+05
R_Conv_1_9_3_1_1_2_1 L0_N1081 L1_N241 1.4280846670e+05
R_Conv_1_9_3_1_2_0_0 L0_N1132 L1_N241 1.1620759255e+05
R_Conv_1_9_3_1_2_0_1 L0_N1133 L1_N241 1.6895116802e+05
R_Conv_1_9_3_1_2_1_0 L0_N1134 L1_N241 1.2455043512e+06
R_Conv_1_9_3_1_2_1_1 L0_N1135 L1_N241 1.1694022847e+05
R_Conv_1_9_3_1_2_2_0 L0_N1136 L1_N241 1.5663616684e+06
R_Conv_1_9_3_1_2_2_1 L0_N1137 L1_N241 2.1466641264e+05
*
R_Conv_1_9_4_0_0_0_0 L0_N1024 L1_N242 3.0927915375e+05
R_Conv_1_9_4_0_0_0_1 L0_N1025 L1_N242 3.6154472179e+05
R_Conv_1_9_4_0_0_1_0 L0_N1026 L1_N242 1.2307612303e+05
R_Conv_1_9_4_0_0_1_1 L0_N1027 L1_N242 1.3361401953e+06
R_Conv_1_9_4_0_0_2_0 L0_N1028 L1_N242 1.1771240850e+06
R_Conv_1_9_4_0_0_2_1 L0_N1029 L1_N242 1.1947062568e+05
R_Conv_1_9_4_0_1_0_0 L0_N1080 L1_N242 3.4555602430e+05
R_Conv_1_9_4_0_1_0_1 L0_N1081 L1_N242 1.2140655673e+05
R_Conv_1_9_4_0_1_1_0 L0_N1082 L1_N242 2.0024008865e+05
R_Conv_1_9_4_0_1_1_1 L0_N1083 L1_N242 1.3019124074e+05
R_Conv_1_9_4_0_1_2_0 L0_N1084 L1_N242 1.1085089352e+05
R_Conv_1_9_4_0_1_2_1 L0_N1085 L1_N242 2.5251460583e+05
R_Conv_1_9_4_0_2_0_0 L0_N1136 L1_N242 1.1040315248e+05
R_Conv_1_9_4_0_2_0_1 L0_N1137 L1_N242 1.2105931856e+05
R_Conv_1_9_4_0_2_1_0 L0_N1138 L1_N242 1.0186236681e+05
R_Conv_1_9_4_0_2_1_1 L0_N1139 L1_N242 3.8798345399e+05
R_Conv_1_9_4_0_2_2_0 L0_N1140 L1_N242 4.4022254443e+06
R_Conv_1_9_4_0_2_2_1 L0_N1141 L1_N242 1.5358515901e+05
*
R_Conv_1_9_4_1_0_0_0 L0_N1024 L1_N243 1.2123709737e+05
R_Conv_1_9_4_1_0_0_1 L0_N1025 L1_N243 1.0849154640e+05
R_Conv_1_9_4_1_0_1_0 L0_N1026 L1_N243 2.0480317885e+05
R_Conv_1_9_4_1_0_1_1 L0_N1027 L1_N243 1.6641635952e+05
R_Conv_1_9_4_1_0_2_0 L0_N1028 L1_N243 1.1683261279e+06
R_Conv_1_9_4_1_0_2_1 L0_N1029 L1_N243 1.1602008983e+05
R_Conv_1_9_4_1_1_0_0 L0_N1080 L1_N243 1.2296662853e+05
R_Conv_1_9_4_1_1_0_1 L0_N1081 L1_N243 1.6882235068e+05
R_Conv_1_9_4_1_1_1_0 L0_N1082 L1_N243 1.0472083211e+05
R_Conv_1_9_4_1_1_1_1 L0_N1083 L1_N243 2.1167619859e+05
R_Conv_1_9_4_1_1_2_0 L0_N1084 L1_N243 1.3518319025e+05
R_Conv_1_9_4_1_1_2_1 L0_N1085 L1_N243 1.4280846670e+05
R_Conv_1_9_4_1_2_0_0 L0_N1136 L1_N243 1.1620759255e+05
R_Conv_1_9_4_1_2_0_1 L0_N1137 L1_N243 1.6895116802e+05
R_Conv_1_9_4_1_2_1_0 L0_N1138 L1_N243 1.2455043512e+06
R_Conv_1_9_4_1_2_1_1 L0_N1139 L1_N243 1.1694022847e+05
R_Conv_1_9_4_1_2_2_0 L0_N1140 L1_N243 1.5663616684e+06
R_Conv_1_9_4_1_2_2_1 L0_N1141 L1_N243 2.1466641264e+05
*
R_Conv_1_9_5_0_0_0_0 L0_N1028 L1_N244 3.0927915375e+05
R_Conv_1_9_5_0_0_0_1 L0_N1029 L1_N244 3.6154472179e+05
R_Conv_1_9_5_0_0_1_0 L0_N1030 L1_N244 1.2307612303e+05
R_Conv_1_9_5_0_0_1_1 L0_N1031 L1_N244 1.3361401953e+06
R_Conv_1_9_5_0_0_2_0 L0_N1032 L1_N244 1.1771240850e+06
R_Conv_1_9_5_0_0_2_1 L0_N1033 L1_N244 1.1947062568e+05
R_Conv_1_9_5_0_1_0_0 L0_N1084 L1_N244 3.4555602430e+05
R_Conv_1_9_5_0_1_0_1 L0_N1085 L1_N244 1.2140655673e+05
R_Conv_1_9_5_0_1_1_0 L0_N1086 L1_N244 2.0024008865e+05
R_Conv_1_9_5_0_1_1_1 L0_N1087 L1_N244 1.3019124074e+05
R_Conv_1_9_5_0_1_2_0 L0_N1088 L1_N244 1.1085089352e+05
R_Conv_1_9_5_0_1_2_1 L0_N1089 L1_N244 2.5251460583e+05
R_Conv_1_9_5_0_2_0_0 L0_N1140 L1_N244 1.1040315248e+05
R_Conv_1_9_5_0_2_0_1 L0_N1141 L1_N244 1.2105931856e+05
R_Conv_1_9_5_0_2_1_0 L0_N1142 L1_N244 1.0186236681e+05
R_Conv_1_9_5_0_2_1_1 L0_N1143 L1_N244 3.8798345399e+05
R_Conv_1_9_5_0_2_2_0 L0_N1144 L1_N244 4.4022254443e+06
R_Conv_1_9_5_0_2_2_1 L0_N1145 L1_N244 1.5358515901e+05
*
R_Conv_1_9_5_1_0_0_0 L0_N1028 L1_N245 1.2123709737e+05
R_Conv_1_9_5_1_0_0_1 L0_N1029 L1_N245 1.0849154640e+05
R_Conv_1_9_5_1_0_1_0 L0_N1030 L1_N245 2.0480317885e+05
R_Conv_1_9_5_1_0_1_1 L0_N1031 L1_N245 1.6641635952e+05
R_Conv_1_9_5_1_0_2_0 L0_N1032 L1_N245 1.1683261279e+06
R_Conv_1_9_5_1_0_2_1 L0_N1033 L1_N245 1.1602008983e+05
R_Conv_1_9_5_1_1_0_0 L0_N1084 L1_N245 1.2296662853e+05
R_Conv_1_9_5_1_1_0_1 L0_N1085 L1_N245 1.6882235068e+05
R_Conv_1_9_5_1_1_1_0 L0_N1086 L1_N245 1.0472083211e+05
R_Conv_1_9_5_1_1_1_1 L0_N1087 L1_N245 2.1167619859e+05
R_Conv_1_9_5_1_1_2_0 L0_N1088 L1_N245 1.3518319025e+05
R_Conv_1_9_5_1_1_2_1 L0_N1089 L1_N245 1.4280846670e+05
R_Conv_1_9_5_1_2_0_0 L0_N1140 L1_N245 1.1620759255e+05
R_Conv_1_9_5_1_2_0_1 L0_N1141 L1_N245 1.6895116802e+05
R_Conv_1_9_5_1_2_1_0 L0_N1142 L1_N245 1.2455043512e+06
R_Conv_1_9_5_1_2_1_1 L0_N1143 L1_N245 1.1694022847e+05
R_Conv_1_9_5_1_2_2_0 L0_N1144 L1_N245 1.5663616684e+06
R_Conv_1_9_5_1_2_2_1 L0_N1145 L1_N245 2.1466641264e+05
*
R_Conv_1_9_6_0_0_0_0 L0_N1032 L1_N246 3.0927915375e+05
R_Conv_1_9_6_0_0_0_1 L0_N1033 L1_N246 3.6154472179e+05
R_Conv_1_9_6_0_0_1_0 L0_N1034 L1_N246 1.2307612303e+05
R_Conv_1_9_6_0_0_1_1 L0_N1035 L1_N246 1.3361401953e+06
R_Conv_1_9_6_0_0_2_0 L0_N1036 L1_N246 1.1771240850e+06
R_Conv_1_9_6_0_0_2_1 L0_N1037 L1_N246 1.1947062568e+05
R_Conv_1_9_6_0_1_0_0 L0_N1088 L1_N246 3.4555602430e+05
R_Conv_1_9_6_0_1_0_1 L0_N1089 L1_N246 1.2140655673e+05
R_Conv_1_9_6_0_1_1_0 L0_N1090 L1_N246 2.0024008865e+05
R_Conv_1_9_6_0_1_1_1 L0_N1091 L1_N246 1.3019124074e+05
R_Conv_1_9_6_0_1_2_0 L0_N1092 L1_N246 1.1085089352e+05
R_Conv_1_9_6_0_1_2_1 L0_N1093 L1_N246 2.5251460583e+05
R_Conv_1_9_6_0_2_0_0 L0_N1144 L1_N246 1.1040315248e+05
R_Conv_1_9_6_0_2_0_1 L0_N1145 L1_N246 1.2105931856e+05
R_Conv_1_9_6_0_2_1_0 L0_N1146 L1_N246 1.0186236681e+05
R_Conv_1_9_6_0_2_1_1 L0_N1147 L1_N246 3.8798345399e+05
R_Conv_1_9_6_0_2_2_0 L0_N1148 L1_N246 4.4022254443e+06
R_Conv_1_9_6_0_2_2_1 L0_N1149 L1_N246 1.5358515901e+05
*
R_Conv_1_9_6_1_0_0_0 L0_N1032 L1_N247 1.2123709737e+05
R_Conv_1_9_6_1_0_0_1 L0_N1033 L1_N247 1.0849154640e+05
R_Conv_1_9_6_1_0_1_0 L0_N1034 L1_N247 2.0480317885e+05
R_Conv_1_9_6_1_0_1_1 L0_N1035 L1_N247 1.6641635952e+05
R_Conv_1_9_6_1_0_2_0 L0_N1036 L1_N247 1.1683261279e+06
R_Conv_1_9_6_1_0_2_1 L0_N1037 L1_N247 1.1602008983e+05
R_Conv_1_9_6_1_1_0_0 L0_N1088 L1_N247 1.2296662853e+05
R_Conv_1_9_6_1_1_0_1 L0_N1089 L1_N247 1.6882235068e+05
R_Conv_1_9_6_1_1_1_0 L0_N1090 L1_N247 1.0472083211e+05
R_Conv_1_9_6_1_1_1_1 L0_N1091 L1_N247 2.1167619859e+05
R_Conv_1_9_6_1_1_2_0 L0_N1092 L1_N247 1.3518319025e+05
R_Conv_1_9_6_1_1_2_1 L0_N1093 L1_N247 1.4280846670e+05
R_Conv_1_9_6_1_2_0_0 L0_N1144 L1_N247 1.1620759255e+05
R_Conv_1_9_6_1_2_0_1 L0_N1145 L1_N247 1.6895116802e+05
R_Conv_1_9_6_1_2_1_0 L0_N1146 L1_N247 1.2455043512e+06
R_Conv_1_9_6_1_2_1_1 L0_N1147 L1_N247 1.1694022847e+05
R_Conv_1_9_6_1_2_2_0 L0_N1148 L1_N247 1.5663616684e+06
R_Conv_1_9_6_1_2_2_1 L0_N1149 L1_N247 2.1466641264e+05
*
R_Conv_1_9_7_0_0_0_0 L0_N1036 L1_N248 3.0927915375e+05
R_Conv_1_9_7_0_0_0_1 L0_N1037 L1_N248 3.6154472179e+05
R_Conv_1_9_7_0_0_1_0 L0_N1038 L1_N248 1.2307612303e+05
R_Conv_1_9_7_0_0_1_1 L0_N1039 L1_N248 1.3361401953e+06
R_Conv_1_9_7_0_0_2_0 L0_N1040 L1_N248 1.1771240850e+06
R_Conv_1_9_7_0_0_2_1 L0_N1041 L1_N248 1.1947062568e+05
R_Conv_1_9_7_0_1_0_0 L0_N1092 L1_N248 3.4555602430e+05
R_Conv_1_9_7_0_1_0_1 L0_N1093 L1_N248 1.2140655673e+05
R_Conv_1_9_7_0_1_1_0 L0_N1094 L1_N248 2.0024008865e+05
R_Conv_1_9_7_0_1_1_1 L0_N1095 L1_N248 1.3019124074e+05
R_Conv_1_9_7_0_1_2_0 L0_N1096 L1_N248 1.1085089352e+05
R_Conv_1_9_7_0_1_2_1 L0_N1097 L1_N248 2.5251460583e+05
R_Conv_1_9_7_0_2_0_0 L0_N1148 L1_N248 1.1040315248e+05
R_Conv_1_9_7_0_2_0_1 L0_N1149 L1_N248 1.2105931856e+05
R_Conv_1_9_7_0_2_1_0 L0_N1150 L1_N248 1.0186236681e+05
R_Conv_1_9_7_0_2_1_1 L0_N1151 L1_N248 3.8798345399e+05
R_Conv_1_9_7_0_2_2_0 L0_N1152 L1_N248 4.4022254443e+06
R_Conv_1_9_7_0_2_2_1 L0_N1153 L1_N248 1.5358515901e+05
*
R_Conv_1_9_7_1_0_0_0 L0_N1036 L1_N249 1.2123709737e+05
R_Conv_1_9_7_1_0_0_1 L0_N1037 L1_N249 1.0849154640e+05
R_Conv_1_9_7_1_0_1_0 L0_N1038 L1_N249 2.0480317885e+05
R_Conv_1_9_7_1_0_1_1 L0_N1039 L1_N249 1.6641635952e+05
R_Conv_1_9_7_1_0_2_0 L0_N1040 L1_N249 1.1683261279e+06
R_Conv_1_9_7_1_0_2_1 L0_N1041 L1_N249 1.1602008983e+05
R_Conv_1_9_7_1_1_0_0 L0_N1092 L1_N249 1.2296662853e+05
R_Conv_1_9_7_1_1_0_1 L0_N1093 L1_N249 1.6882235068e+05
R_Conv_1_9_7_1_1_1_0 L0_N1094 L1_N249 1.0472083211e+05
R_Conv_1_9_7_1_1_1_1 L0_N1095 L1_N249 2.1167619859e+05
R_Conv_1_9_7_1_1_2_0 L0_N1096 L1_N249 1.3518319025e+05
R_Conv_1_9_7_1_1_2_1 L0_N1097 L1_N249 1.4280846670e+05
R_Conv_1_9_7_1_2_0_0 L0_N1148 L1_N249 1.1620759255e+05
R_Conv_1_9_7_1_2_0_1 L0_N1149 L1_N249 1.6895116802e+05
R_Conv_1_9_7_1_2_1_0 L0_N1150 L1_N249 1.2455043512e+06
R_Conv_1_9_7_1_2_1_1 L0_N1151 L1_N249 1.1694022847e+05
R_Conv_1_9_7_1_2_2_0 L0_N1152 L1_N249 1.5663616684e+06
R_Conv_1_9_7_1_2_2_1 L0_N1153 L1_N249 2.1466641264e+05
*
R_Conv_1_9_8_0_0_0_0 L0_N1040 L1_N250 3.0927915375e+05
R_Conv_1_9_8_0_0_0_1 L0_N1041 L1_N250 3.6154472179e+05
R_Conv_1_9_8_0_0_1_0 L0_N1042 L1_N250 1.2307612303e+05
R_Conv_1_9_8_0_0_1_1 L0_N1043 L1_N250 1.3361401953e+06
R_Conv_1_9_8_0_0_2_0 L0_N1044 L1_N250 1.1771240850e+06
R_Conv_1_9_8_0_0_2_1 L0_N1045 L1_N250 1.1947062568e+05
R_Conv_1_9_8_0_1_0_0 L0_N1096 L1_N250 3.4555602430e+05
R_Conv_1_9_8_0_1_0_1 L0_N1097 L1_N250 1.2140655673e+05
R_Conv_1_9_8_0_1_1_0 L0_N1098 L1_N250 2.0024008865e+05
R_Conv_1_9_8_0_1_1_1 L0_N1099 L1_N250 1.3019124074e+05
R_Conv_1_9_8_0_1_2_0 L0_N1100 L1_N250 1.1085089352e+05
R_Conv_1_9_8_0_1_2_1 L0_N1101 L1_N250 2.5251460583e+05
R_Conv_1_9_8_0_2_0_0 L0_N1152 L1_N250 1.1040315248e+05
R_Conv_1_9_8_0_2_0_1 L0_N1153 L1_N250 1.2105931856e+05
R_Conv_1_9_8_0_2_1_0 L0_N1154 L1_N250 1.0186236681e+05
R_Conv_1_9_8_0_2_1_1 L0_N1155 L1_N250 3.8798345399e+05
R_Conv_1_9_8_0_2_2_0 L0_N1156 L1_N250 4.4022254443e+06
R_Conv_1_9_8_0_2_2_1 L0_N1157 L1_N250 1.5358515901e+05
*
R_Conv_1_9_8_1_0_0_0 L0_N1040 L1_N251 1.2123709737e+05
R_Conv_1_9_8_1_0_0_1 L0_N1041 L1_N251 1.0849154640e+05
R_Conv_1_9_8_1_0_1_0 L0_N1042 L1_N251 2.0480317885e+05
R_Conv_1_9_8_1_0_1_1 L0_N1043 L1_N251 1.6641635952e+05
R_Conv_1_9_8_1_0_2_0 L0_N1044 L1_N251 1.1683261279e+06
R_Conv_1_9_8_1_0_2_1 L0_N1045 L1_N251 1.1602008983e+05
R_Conv_1_9_8_1_1_0_0 L0_N1096 L1_N251 1.2296662853e+05
R_Conv_1_9_8_1_1_0_1 L0_N1097 L1_N251 1.6882235068e+05
R_Conv_1_9_8_1_1_1_0 L0_N1098 L1_N251 1.0472083211e+05
R_Conv_1_9_8_1_1_1_1 L0_N1099 L1_N251 2.1167619859e+05
R_Conv_1_9_8_1_1_2_0 L0_N1100 L1_N251 1.3518319025e+05
R_Conv_1_9_8_1_1_2_1 L0_N1101 L1_N251 1.4280846670e+05
R_Conv_1_9_8_1_2_0_0 L0_N1152 L1_N251 1.1620759255e+05
R_Conv_1_9_8_1_2_0_1 L0_N1153 L1_N251 1.6895116802e+05
R_Conv_1_9_8_1_2_1_0 L0_N1154 L1_N251 1.2455043512e+06
R_Conv_1_9_8_1_2_1_1 L0_N1155 L1_N251 1.1694022847e+05
R_Conv_1_9_8_1_2_2_0 L0_N1156 L1_N251 1.5663616684e+06
R_Conv_1_9_8_1_2_2_1 L0_N1157 L1_N251 2.1466641264e+05
*
R_Conv_1_9_9_0_0_0_0 L0_N1044 L1_N252 3.0927915375e+05
R_Conv_1_9_9_0_0_0_1 L0_N1045 L1_N252 3.6154472179e+05
R_Conv_1_9_9_0_0_1_0 L0_N1046 L1_N252 1.2307612303e+05
R_Conv_1_9_9_0_0_1_1 L0_N1047 L1_N252 1.3361401953e+06
R_Conv_1_9_9_0_0_2_0 L0_N1048 L1_N252 1.1771240850e+06
R_Conv_1_9_9_0_0_2_1 L0_N1049 L1_N252 1.1947062568e+05
R_Conv_1_9_9_0_1_0_0 L0_N1100 L1_N252 3.4555602430e+05
R_Conv_1_9_9_0_1_0_1 L0_N1101 L1_N252 1.2140655673e+05
R_Conv_1_9_9_0_1_1_0 L0_N1102 L1_N252 2.0024008865e+05
R_Conv_1_9_9_0_1_1_1 L0_N1103 L1_N252 1.3019124074e+05
R_Conv_1_9_9_0_1_2_0 L0_N1104 L1_N252 1.1085089352e+05
R_Conv_1_9_9_0_1_2_1 L0_N1105 L1_N252 2.5251460583e+05
R_Conv_1_9_9_0_2_0_0 L0_N1156 L1_N252 1.1040315248e+05
R_Conv_1_9_9_0_2_0_1 L0_N1157 L1_N252 1.2105931856e+05
R_Conv_1_9_9_0_2_1_0 L0_N1158 L1_N252 1.0186236681e+05
R_Conv_1_9_9_0_2_1_1 L0_N1159 L1_N252 3.8798345399e+05
R_Conv_1_9_9_0_2_2_0 L0_N1160 L1_N252 4.4022254443e+06
R_Conv_1_9_9_0_2_2_1 L0_N1161 L1_N252 1.5358515901e+05
*
R_Conv_1_9_9_1_0_0_0 L0_N1044 L1_N253 1.2123709737e+05
R_Conv_1_9_9_1_0_0_1 L0_N1045 L1_N253 1.0849154640e+05
R_Conv_1_9_9_1_0_1_0 L0_N1046 L1_N253 2.0480317885e+05
R_Conv_1_9_9_1_0_1_1 L0_N1047 L1_N253 1.6641635952e+05
R_Conv_1_9_9_1_0_2_0 L0_N1048 L1_N253 1.1683261279e+06
R_Conv_1_9_9_1_0_2_1 L0_N1049 L1_N253 1.1602008983e+05
R_Conv_1_9_9_1_1_0_0 L0_N1100 L1_N253 1.2296662853e+05
R_Conv_1_9_9_1_1_0_1 L0_N1101 L1_N253 1.6882235068e+05
R_Conv_1_9_9_1_1_1_0 L0_N1102 L1_N253 1.0472083211e+05
R_Conv_1_9_9_1_1_1_1 L0_N1103 L1_N253 2.1167619859e+05
R_Conv_1_9_9_1_1_2_0 L0_N1104 L1_N253 1.3518319025e+05
R_Conv_1_9_9_1_1_2_1 L0_N1105 L1_N253 1.4280846670e+05
R_Conv_1_9_9_1_2_0_0 L0_N1156 L1_N253 1.1620759255e+05
R_Conv_1_9_9_1_2_0_1 L0_N1157 L1_N253 1.6895116802e+05
R_Conv_1_9_9_1_2_1_0 L0_N1158 L1_N253 1.2455043512e+06
R_Conv_1_9_9_1_2_1_1 L0_N1159 L1_N253 1.1694022847e+05
R_Conv_1_9_9_1_2_2_0 L0_N1160 L1_N253 1.5663616684e+06
R_Conv_1_9_9_1_2_2_1 L0_N1161 L1_N253 2.1466641264e+05
*
R_Conv_1_9_10_0_0_0_0 L0_N1048 L1_N254 3.0927915375e+05
R_Conv_1_9_10_0_0_0_1 L0_N1049 L1_N254 3.6154472179e+05
R_Conv_1_9_10_0_0_1_0 L0_N1050 L1_N254 1.2307612303e+05
R_Conv_1_9_10_0_0_1_1 L0_N1051 L1_N254 1.3361401953e+06
R_Conv_1_9_10_0_0_2_0 L0_N1052 L1_N254 1.1771240850e+06
R_Conv_1_9_10_0_0_2_1 L0_N1053 L1_N254 1.1947062568e+05
R_Conv_1_9_10_0_1_0_0 L0_N1104 L1_N254 3.4555602430e+05
R_Conv_1_9_10_0_1_0_1 L0_N1105 L1_N254 1.2140655673e+05
R_Conv_1_9_10_0_1_1_0 L0_N1106 L1_N254 2.0024008865e+05
R_Conv_1_9_10_0_1_1_1 L0_N1107 L1_N254 1.3019124074e+05
R_Conv_1_9_10_0_1_2_0 L0_N1108 L1_N254 1.1085089352e+05
R_Conv_1_9_10_0_1_2_1 L0_N1109 L1_N254 2.5251460583e+05
R_Conv_1_9_10_0_2_0_0 L0_N1160 L1_N254 1.1040315248e+05
R_Conv_1_9_10_0_2_0_1 L0_N1161 L1_N254 1.2105931856e+05
R_Conv_1_9_10_0_2_1_0 L0_N1162 L1_N254 1.0186236681e+05
R_Conv_1_9_10_0_2_1_1 L0_N1163 L1_N254 3.8798345399e+05
R_Conv_1_9_10_0_2_2_0 L0_N1164 L1_N254 4.4022254443e+06
R_Conv_1_9_10_0_2_2_1 L0_N1165 L1_N254 1.5358515901e+05
*
R_Conv_1_9_10_1_0_0_0 L0_N1048 L1_N255 1.2123709737e+05
R_Conv_1_9_10_1_0_0_1 L0_N1049 L1_N255 1.0849154640e+05
R_Conv_1_9_10_1_0_1_0 L0_N1050 L1_N255 2.0480317885e+05
R_Conv_1_9_10_1_0_1_1 L0_N1051 L1_N255 1.6641635952e+05
R_Conv_1_9_10_1_0_2_0 L0_N1052 L1_N255 1.1683261279e+06
R_Conv_1_9_10_1_0_2_1 L0_N1053 L1_N255 1.1602008983e+05
R_Conv_1_9_10_1_1_0_0 L0_N1104 L1_N255 1.2296662853e+05
R_Conv_1_9_10_1_1_0_1 L0_N1105 L1_N255 1.6882235068e+05
R_Conv_1_9_10_1_1_1_0 L0_N1106 L1_N255 1.0472083211e+05
R_Conv_1_9_10_1_1_1_1 L0_N1107 L1_N255 2.1167619859e+05
R_Conv_1_9_10_1_1_2_0 L0_N1108 L1_N255 1.3518319025e+05
R_Conv_1_9_10_1_1_2_1 L0_N1109 L1_N255 1.4280846670e+05
R_Conv_1_9_10_1_2_0_0 L0_N1160 L1_N255 1.1620759255e+05
R_Conv_1_9_10_1_2_0_1 L0_N1161 L1_N255 1.6895116802e+05
R_Conv_1_9_10_1_2_1_0 L0_N1162 L1_N255 1.2455043512e+06
R_Conv_1_9_10_1_2_1_1 L0_N1163 L1_N255 1.1694022847e+05
R_Conv_1_9_10_1_2_2_0 L0_N1164 L1_N255 1.5663616684e+06
R_Conv_1_9_10_1_2_2_1 L0_N1165 L1_N255 2.1466641264e+05
*
R_Conv_1_9_11_0_0_0_0 L0_N1052 L1_N256 3.0927915375e+05
R_Conv_1_9_11_0_0_0_1 L0_N1053 L1_N256 3.6154472179e+05
R_Conv_1_9_11_0_0_1_0 L0_N1054 L1_N256 1.2307612303e+05
R_Conv_1_9_11_0_0_1_1 L0_N1055 L1_N256 1.3361401953e+06
R_Conv_1_9_11_0_0_2_0 L0_N1056 L1_N256 1.1771240850e+06
R_Conv_1_9_11_0_0_2_1 L0_N1057 L1_N256 1.1947062568e+05
R_Conv_1_9_11_0_1_0_0 L0_N1108 L1_N256 3.4555602430e+05
R_Conv_1_9_11_0_1_0_1 L0_N1109 L1_N256 1.2140655673e+05
R_Conv_1_9_11_0_1_1_0 L0_N1110 L1_N256 2.0024008865e+05
R_Conv_1_9_11_0_1_1_1 L0_N1111 L1_N256 1.3019124074e+05
R_Conv_1_9_11_0_1_2_0 L0_N1112 L1_N256 1.1085089352e+05
R_Conv_1_9_11_0_1_2_1 L0_N1113 L1_N256 2.5251460583e+05
R_Conv_1_9_11_0_2_0_0 L0_N1164 L1_N256 1.1040315248e+05
R_Conv_1_9_11_0_2_0_1 L0_N1165 L1_N256 1.2105931856e+05
R_Conv_1_9_11_0_2_1_0 L0_N1166 L1_N256 1.0186236681e+05
R_Conv_1_9_11_0_2_1_1 L0_N1167 L1_N256 3.8798345399e+05
R_Conv_1_9_11_0_2_2_0 L0_N1168 L1_N256 4.4022254443e+06
R_Conv_1_9_11_0_2_2_1 L0_N1169 L1_N256 1.5358515901e+05
*
R_Conv_1_9_11_1_0_0_0 L0_N1052 L1_N257 1.2123709737e+05
R_Conv_1_9_11_1_0_0_1 L0_N1053 L1_N257 1.0849154640e+05
R_Conv_1_9_11_1_0_1_0 L0_N1054 L1_N257 2.0480317885e+05
R_Conv_1_9_11_1_0_1_1 L0_N1055 L1_N257 1.6641635952e+05
R_Conv_1_9_11_1_0_2_0 L0_N1056 L1_N257 1.1683261279e+06
R_Conv_1_9_11_1_0_2_1 L0_N1057 L1_N257 1.1602008983e+05
R_Conv_1_9_11_1_1_0_0 L0_N1108 L1_N257 1.2296662853e+05
R_Conv_1_9_11_1_1_0_1 L0_N1109 L1_N257 1.6882235068e+05
R_Conv_1_9_11_1_1_1_0 L0_N1110 L1_N257 1.0472083211e+05
R_Conv_1_9_11_1_1_1_1 L0_N1111 L1_N257 2.1167619859e+05
R_Conv_1_9_11_1_1_2_0 L0_N1112 L1_N257 1.3518319025e+05
R_Conv_1_9_11_1_1_2_1 L0_N1113 L1_N257 1.4280846670e+05
R_Conv_1_9_11_1_2_0_0 L0_N1164 L1_N257 1.1620759255e+05
R_Conv_1_9_11_1_2_0_1 L0_N1165 L1_N257 1.6895116802e+05
R_Conv_1_9_11_1_2_1_0 L0_N1166 L1_N257 1.2455043512e+06
R_Conv_1_9_11_1_2_1_1 L0_N1167 L1_N257 1.1694022847e+05
R_Conv_1_9_11_1_2_2_0 L0_N1168 L1_N257 1.5663616684e+06
R_Conv_1_9_11_1_2_2_1 L0_N1169 L1_N257 2.1466641264e+05
*
R_Conv_1_9_12_0_0_0_0 L0_N1056 L1_N258 3.0927915375e+05
R_Conv_1_9_12_0_0_0_1 L0_N1057 L1_N258 3.6154472179e+05
R_Conv_1_9_12_0_0_1_0 L0_N1058 L1_N258 1.2307612303e+05
R_Conv_1_9_12_0_0_1_1 L0_N1059 L1_N258 1.3361401953e+06
R_Conv_1_9_12_0_0_2_0 L0_N1060 L1_N258 1.1771240850e+06
R_Conv_1_9_12_0_0_2_1 L0_N1061 L1_N258 1.1947062568e+05
R_Conv_1_9_12_0_1_0_0 L0_N1112 L1_N258 3.4555602430e+05
R_Conv_1_9_12_0_1_0_1 L0_N1113 L1_N258 1.2140655673e+05
R_Conv_1_9_12_0_1_1_0 L0_N1114 L1_N258 2.0024008865e+05
R_Conv_1_9_12_0_1_1_1 L0_N1115 L1_N258 1.3019124074e+05
R_Conv_1_9_12_0_1_2_0 L0_N1116 L1_N258 1.1085089352e+05
R_Conv_1_9_12_0_1_2_1 L0_N1117 L1_N258 2.5251460583e+05
R_Conv_1_9_12_0_2_0_0 L0_N1168 L1_N258 1.1040315248e+05
R_Conv_1_9_12_0_2_0_1 L0_N1169 L1_N258 1.2105931856e+05
R_Conv_1_9_12_0_2_1_0 L0_N1170 L1_N258 1.0186236681e+05
R_Conv_1_9_12_0_2_1_1 L0_N1171 L1_N258 3.8798345399e+05
R_Conv_1_9_12_0_2_2_0 L0_N1172 L1_N258 4.4022254443e+06
R_Conv_1_9_12_0_2_2_1 L0_N1173 L1_N258 1.5358515901e+05
*
R_Conv_1_9_12_1_0_0_0 L0_N1056 L1_N259 1.2123709737e+05
R_Conv_1_9_12_1_0_0_1 L0_N1057 L1_N259 1.0849154640e+05
R_Conv_1_9_12_1_0_1_0 L0_N1058 L1_N259 2.0480317885e+05
R_Conv_1_9_12_1_0_1_1 L0_N1059 L1_N259 1.6641635952e+05
R_Conv_1_9_12_1_0_2_0 L0_N1060 L1_N259 1.1683261279e+06
R_Conv_1_9_12_1_0_2_1 L0_N1061 L1_N259 1.1602008983e+05
R_Conv_1_9_12_1_1_0_0 L0_N1112 L1_N259 1.2296662853e+05
R_Conv_1_9_12_1_1_0_1 L0_N1113 L1_N259 1.6882235068e+05
R_Conv_1_9_12_1_1_1_0 L0_N1114 L1_N259 1.0472083211e+05
R_Conv_1_9_12_1_1_1_1 L0_N1115 L1_N259 2.1167619859e+05
R_Conv_1_9_12_1_1_2_0 L0_N1116 L1_N259 1.3518319025e+05
R_Conv_1_9_12_1_1_2_1 L0_N1117 L1_N259 1.4280846670e+05
R_Conv_1_9_12_1_2_0_0 L0_N1168 L1_N259 1.1620759255e+05
R_Conv_1_9_12_1_2_0_1 L0_N1169 L1_N259 1.6895116802e+05
R_Conv_1_9_12_1_2_1_0 L0_N1170 L1_N259 1.2455043512e+06
R_Conv_1_9_12_1_2_1_1 L0_N1171 L1_N259 1.1694022847e+05
R_Conv_1_9_12_1_2_2_0 L0_N1172 L1_N259 1.5663616684e+06
R_Conv_1_9_12_1_2_2_1 L0_N1173 L1_N259 2.1466641264e+05
*
R_Conv_1_10_0_0_0_0_0 L0_N1120 L1_N260 3.0927915375e+05
R_Conv_1_10_0_0_0_0_1 L0_N1121 L1_N260 3.6154472179e+05
R_Conv_1_10_0_0_0_1_0 L0_N1122 L1_N260 1.2307612303e+05
R_Conv_1_10_0_0_0_1_1 L0_N1123 L1_N260 1.3361401953e+06
R_Conv_1_10_0_0_0_2_0 L0_N1124 L1_N260 1.1771240850e+06
R_Conv_1_10_0_0_0_2_1 L0_N1125 L1_N260 1.1947062568e+05
R_Conv_1_10_0_0_1_0_0 L0_N1176 L1_N260 3.4555602430e+05
R_Conv_1_10_0_0_1_0_1 L0_N1177 L1_N260 1.2140655673e+05
R_Conv_1_10_0_0_1_1_0 L0_N1178 L1_N260 2.0024008865e+05
R_Conv_1_10_0_0_1_1_1 L0_N1179 L1_N260 1.3019124074e+05
R_Conv_1_10_0_0_1_2_0 L0_N1180 L1_N260 1.1085089352e+05
R_Conv_1_10_0_0_1_2_1 L0_N1181 L1_N260 2.5251460583e+05
R_Conv_1_10_0_0_2_0_0 L0_N1232 L1_N260 1.1040315248e+05
R_Conv_1_10_0_0_2_0_1 L0_N1233 L1_N260 1.2105931856e+05
R_Conv_1_10_0_0_2_1_0 L0_N1234 L1_N260 1.0186236681e+05
R_Conv_1_10_0_0_2_1_1 L0_N1235 L1_N260 3.8798345399e+05
R_Conv_1_10_0_0_2_2_0 L0_N1236 L1_N260 4.4022254443e+06
R_Conv_1_10_0_0_2_2_1 L0_N1237 L1_N260 1.5358515901e+05
*
R_Conv_1_10_0_1_0_0_0 L0_N1120 L1_N261 1.2123709737e+05
R_Conv_1_10_0_1_0_0_1 L0_N1121 L1_N261 1.0849154640e+05
R_Conv_1_10_0_1_0_1_0 L0_N1122 L1_N261 2.0480317885e+05
R_Conv_1_10_0_1_0_1_1 L0_N1123 L1_N261 1.6641635952e+05
R_Conv_1_10_0_1_0_2_0 L0_N1124 L1_N261 1.1683261279e+06
R_Conv_1_10_0_1_0_2_1 L0_N1125 L1_N261 1.1602008983e+05
R_Conv_1_10_0_1_1_0_0 L0_N1176 L1_N261 1.2296662853e+05
R_Conv_1_10_0_1_1_0_1 L0_N1177 L1_N261 1.6882235068e+05
R_Conv_1_10_0_1_1_1_0 L0_N1178 L1_N261 1.0472083211e+05
R_Conv_1_10_0_1_1_1_1 L0_N1179 L1_N261 2.1167619859e+05
R_Conv_1_10_0_1_1_2_0 L0_N1180 L1_N261 1.3518319025e+05
R_Conv_1_10_0_1_1_2_1 L0_N1181 L1_N261 1.4280846670e+05
R_Conv_1_10_0_1_2_0_0 L0_N1232 L1_N261 1.1620759255e+05
R_Conv_1_10_0_1_2_0_1 L0_N1233 L1_N261 1.6895116802e+05
R_Conv_1_10_0_1_2_1_0 L0_N1234 L1_N261 1.2455043512e+06
R_Conv_1_10_0_1_2_1_1 L0_N1235 L1_N261 1.1694022847e+05
R_Conv_1_10_0_1_2_2_0 L0_N1236 L1_N261 1.5663616684e+06
R_Conv_1_10_0_1_2_2_1 L0_N1237 L1_N261 2.1466641264e+05
*
R_Conv_1_10_1_0_0_0_0 L0_N1124 L1_N262 3.0927915375e+05
R_Conv_1_10_1_0_0_0_1 L0_N1125 L1_N262 3.6154472179e+05
R_Conv_1_10_1_0_0_1_0 L0_N1126 L1_N262 1.2307612303e+05
R_Conv_1_10_1_0_0_1_1 L0_N1127 L1_N262 1.3361401953e+06
R_Conv_1_10_1_0_0_2_0 L0_N1128 L1_N262 1.1771240850e+06
R_Conv_1_10_1_0_0_2_1 L0_N1129 L1_N262 1.1947062568e+05
R_Conv_1_10_1_0_1_0_0 L0_N1180 L1_N262 3.4555602430e+05
R_Conv_1_10_1_0_1_0_1 L0_N1181 L1_N262 1.2140655673e+05
R_Conv_1_10_1_0_1_1_0 L0_N1182 L1_N262 2.0024008865e+05
R_Conv_1_10_1_0_1_1_1 L0_N1183 L1_N262 1.3019124074e+05
R_Conv_1_10_1_0_1_2_0 L0_N1184 L1_N262 1.1085089352e+05
R_Conv_1_10_1_0_1_2_1 L0_N1185 L1_N262 2.5251460583e+05
R_Conv_1_10_1_0_2_0_0 L0_N1236 L1_N262 1.1040315248e+05
R_Conv_1_10_1_0_2_0_1 L0_N1237 L1_N262 1.2105931856e+05
R_Conv_1_10_1_0_2_1_0 L0_N1238 L1_N262 1.0186236681e+05
R_Conv_1_10_1_0_2_1_1 L0_N1239 L1_N262 3.8798345399e+05
R_Conv_1_10_1_0_2_2_0 L0_N1240 L1_N262 4.4022254443e+06
R_Conv_1_10_1_0_2_2_1 L0_N1241 L1_N262 1.5358515901e+05
*
R_Conv_1_10_1_1_0_0_0 L0_N1124 L1_N263 1.2123709737e+05
R_Conv_1_10_1_1_0_0_1 L0_N1125 L1_N263 1.0849154640e+05
R_Conv_1_10_1_1_0_1_0 L0_N1126 L1_N263 2.0480317885e+05
R_Conv_1_10_1_1_0_1_1 L0_N1127 L1_N263 1.6641635952e+05
R_Conv_1_10_1_1_0_2_0 L0_N1128 L1_N263 1.1683261279e+06
R_Conv_1_10_1_1_0_2_1 L0_N1129 L1_N263 1.1602008983e+05
R_Conv_1_10_1_1_1_0_0 L0_N1180 L1_N263 1.2296662853e+05
R_Conv_1_10_1_1_1_0_1 L0_N1181 L1_N263 1.6882235068e+05
R_Conv_1_10_1_1_1_1_0 L0_N1182 L1_N263 1.0472083211e+05
R_Conv_1_10_1_1_1_1_1 L0_N1183 L1_N263 2.1167619859e+05
R_Conv_1_10_1_1_1_2_0 L0_N1184 L1_N263 1.3518319025e+05
R_Conv_1_10_1_1_1_2_1 L0_N1185 L1_N263 1.4280846670e+05
R_Conv_1_10_1_1_2_0_0 L0_N1236 L1_N263 1.1620759255e+05
R_Conv_1_10_1_1_2_0_1 L0_N1237 L1_N263 1.6895116802e+05
R_Conv_1_10_1_1_2_1_0 L0_N1238 L1_N263 1.2455043512e+06
R_Conv_1_10_1_1_2_1_1 L0_N1239 L1_N263 1.1694022847e+05
R_Conv_1_10_1_1_2_2_0 L0_N1240 L1_N263 1.5663616684e+06
R_Conv_1_10_1_1_2_2_1 L0_N1241 L1_N263 2.1466641264e+05
*
R_Conv_1_10_2_0_0_0_0 L0_N1128 L1_N264 3.0927915375e+05
R_Conv_1_10_2_0_0_0_1 L0_N1129 L1_N264 3.6154472179e+05
R_Conv_1_10_2_0_0_1_0 L0_N1130 L1_N264 1.2307612303e+05
R_Conv_1_10_2_0_0_1_1 L0_N1131 L1_N264 1.3361401953e+06
R_Conv_1_10_2_0_0_2_0 L0_N1132 L1_N264 1.1771240850e+06
R_Conv_1_10_2_0_0_2_1 L0_N1133 L1_N264 1.1947062568e+05
R_Conv_1_10_2_0_1_0_0 L0_N1184 L1_N264 3.4555602430e+05
R_Conv_1_10_2_0_1_0_1 L0_N1185 L1_N264 1.2140655673e+05
R_Conv_1_10_2_0_1_1_0 L0_N1186 L1_N264 2.0024008865e+05
R_Conv_1_10_2_0_1_1_1 L0_N1187 L1_N264 1.3019124074e+05
R_Conv_1_10_2_0_1_2_0 L0_N1188 L1_N264 1.1085089352e+05
R_Conv_1_10_2_0_1_2_1 L0_N1189 L1_N264 2.5251460583e+05
R_Conv_1_10_2_0_2_0_0 L0_N1240 L1_N264 1.1040315248e+05
R_Conv_1_10_2_0_2_0_1 L0_N1241 L1_N264 1.2105931856e+05
R_Conv_1_10_2_0_2_1_0 L0_N1242 L1_N264 1.0186236681e+05
R_Conv_1_10_2_0_2_1_1 L0_N1243 L1_N264 3.8798345399e+05
R_Conv_1_10_2_0_2_2_0 L0_N1244 L1_N264 4.4022254443e+06
R_Conv_1_10_2_0_2_2_1 L0_N1245 L1_N264 1.5358515901e+05
*
R_Conv_1_10_2_1_0_0_0 L0_N1128 L1_N265 1.2123709737e+05
R_Conv_1_10_2_1_0_0_1 L0_N1129 L1_N265 1.0849154640e+05
R_Conv_1_10_2_1_0_1_0 L0_N1130 L1_N265 2.0480317885e+05
R_Conv_1_10_2_1_0_1_1 L0_N1131 L1_N265 1.6641635952e+05
R_Conv_1_10_2_1_0_2_0 L0_N1132 L1_N265 1.1683261279e+06
R_Conv_1_10_2_1_0_2_1 L0_N1133 L1_N265 1.1602008983e+05
R_Conv_1_10_2_1_1_0_0 L0_N1184 L1_N265 1.2296662853e+05
R_Conv_1_10_2_1_1_0_1 L0_N1185 L1_N265 1.6882235068e+05
R_Conv_1_10_2_1_1_1_0 L0_N1186 L1_N265 1.0472083211e+05
R_Conv_1_10_2_1_1_1_1 L0_N1187 L1_N265 2.1167619859e+05
R_Conv_1_10_2_1_1_2_0 L0_N1188 L1_N265 1.3518319025e+05
R_Conv_1_10_2_1_1_2_1 L0_N1189 L1_N265 1.4280846670e+05
R_Conv_1_10_2_1_2_0_0 L0_N1240 L1_N265 1.1620759255e+05
R_Conv_1_10_2_1_2_0_1 L0_N1241 L1_N265 1.6895116802e+05
R_Conv_1_10_2_1_2_1_0 L0_N1242 L1_N265 1.2455043512e+06
R_Conv_1_10_2_1_2_1_1 L0_N1243 L1_N265 1.1694022847e+05
R_Conv_1_10_2_1_2_2_0 L0_N1244 L1_N265 1.5663616684e+06
R_Conv_1_10_2_1_2_2_1 L0_N1245 L1_N265 2.1466641264e+05
*
R_Conv_1_10_3_0_0_0_0 L0_N1132 L1_N266 3.0927915375e+05
R_Conv_1_10_3_0_0_0_1 L0_N1133 L1_N266 3.6154472179e+05
R_Conv_1_10_3_0_0_1_0 L0_N1134 L1_N266 1.2307612303e+05
R_Conv_1_10_3_0_0_1_1 L0_N1135 L1_N266 1.3361401953e+06
R_Conv_1_10_3_0_0_2_0 L0_N1136 L1_N266 1.1771240850e+06
R_Conv_1_10_3_0_0_2_1 L0_N1137 L1_N266 1.1947062568e+05
R_Conv_1_10_3_0_1_0_0 L0_N1188 L1_N266 3.4555602430e+05
R_Conv_1_10_3_0_1_0_1 L0_N1189 L1_N266 1.2140655673e+05
R_Conv_1_10_3_0_1_1_0 L0_N1190 L1_N266 2.0024008865e+05
R_Conv_1_10_3_0_1_1_1 L0_N1191 L1_N266 1.3019124074e+05
R_Conv_1_10_3_0_1_2_0 L0_N1192 L1_N266 1.1085089352e+05
R_Conv_1_10_3_0_1_2_1 L0_N1193 L1_N266 2.5251460583e+05
R_Conv_1_10_3_0_2_0_0 L0_N1244 L1_N266 1.1040315248e+05
R_Conv_1_10_3_0_2_0_1 L0_N1245 L1_N266 1.2105931856e+05
R_Conv_1_10_3_0_2_1_0 L0_N1246 L1_N266 1.0186236681e+05
R_Conv_1_10_3_0_2_1_1 L0_N1247 L1_N266 3.8798345399e+05
R_Conv_1_10_3_0_2_2_0 L0_N1248 L1_N266 4.4022254443e+06
R_Conv_1_10_3_0_2_2_1 L0_N1249 L1_N266 1.5358515901e+05
*
R_Conv_1_10_3_1_0_0_0 L0_N1132 L1_N267 1.2123709737e+05
R_Conv_1_10_3_1_0_0_1 L0_N1133 L1_N267 1.0849154640e+05
R_Conv_1_10_3_1_0_1_0 L0_N1134 L1_N267 2.0480317885e+05
R_Conv_1_10_3_1_0_1_1 L0_N1135 L1_N267 1.6641635952e+05
R_Conv_1_10_3_1_0_2_0 L0_N1136 L1_N267 1.1683261279e+06
R_Conv_1_10_3_1_0_2_1 L0_N1137 L1_N267 1.1602008983e+05
R_Conv_1_10_3_1_1_0_0 L0_N1188 L1_N267 1.2296662853e+05
R_Conv_1_10_3_1_1_0_1 L0_N1189 L1_N267 1.6882235068e+05
R_Conv_1_10_3_1_1_1_0 L0_N1190 L1_N267 1.0472083211e+05
R_Conv_1_10_3_1_1_1_1 L0_N1191 L1_N267 2.1167619859e+05
R_Conv_1_10_3_1_1_2_0 L0_N1192 L1_N267 1.3518319025e+05
R_Conv_1_10_3_1_1_2_1 L0_N1193 L1_N267 1.4280846670e+05
R_Conv_1_10_3_1_2_0_0 L0_N1244 L1_N267 1.1620759255e+05
R_Conv_1_10_3_1_2_0_1 L0_N1245 L1_N267 1.6895116802e+05
R_Conv_1_10_3_1_2_1_0 L0_N1246 L1_N267 1.2455043512e+06
R_Conv_1_10_3_1_2_1_1 L0_N1247 L1_N267 1.1694022847e+05
R_Conv_1_10_3_1_2_2_0 L0_N1248 L1_N267 1.5663616684e+06
R_Conv_1_10_3_1_2_2_1 L0_N1249 L1_N267 2.1466641264e+05
*
R_Conv_1_10_4_0_0_0_0 L0_N1136 L1_N268 3.0927915375e+05
R_Conv_1_10_4_0_0_0_1 L0_N1137 L1_N268 3.6154472179e+05
R_Conv_1_10_4_0_0_1_0 L0_N1138 L1_N268 1.2307612303e+05
R_Conv_1_10_4_0_0_1_1 L0_N1139 L1_N268 1.3361401953e+06
R_Conv_1_10_4_0_0_2_0 L0_N1140 L1_N268 1.1771240850e+06
R_Conv_1_10_4_0_0_2_1 L0_N1141 L1_N268 1.1947062568e+05
R_Conv_1_10_4_0_1_0_0 L0_N1192 L1_N268 3.4555602430e+05
R_Conv_1_10_4_0_1_0_1 L0_N1193 L1_N268 1.2140655673e+05
R_Conv_1_10_4_0_1_1_0 L0_N1194 L1_N268 2.0024008865e+05
R_Conv_1_10_4_0_1_1_1 L0_N1195 L1_N268 1.3019124074e+05
R_Conv_1_10_4_0_1_2_0 L0_N1196 L1_N268 1.1085089352e+05
R_Conv_1_10_4_0_1_2_1 L0_N1197 L1_N268 2.5251460583e+05
R_Conv_1_10_4_0_2_0_0 L0_N1248 L1_N268 1.1040315248e+05
R_Conv_1_10_4_0_2_0_1 L0_N1249 L1_N268 1.2105931856e+05
R_Conv_1_10_4_0_2_1_0 L0_N1250 L1_N268 1.0186236681e+05
R_Conv_1_10_4_0_2_1_1 L0_N1251 L1_N268 3.8798345399e+05
R_Conv_1_10_4_0_2_2_0 L0_N1252 L1_N268 4.4022254443e+06
R_Conv_1_10_4_0_2_2_1 L0_N1253 L1_N268 1.5358515901e+05
*
R_Conv_1_10_4_1_0_0_0 L0_N1136 L1_N269 1.2123709737e+05
R_Conv_1_10_4_1_0_0_1 L0_N1137 L1_N269 1.0849154640e+05
R_Conv_1_10_4_1_0_1_0 L0_N1138 L1_N269 2.0480317885e+05
R_Conv_1_10_4_1_0_1_1 L0_N1139 L1_N269 1.6641635952e+05
R_Conv_1_10_4_1_0_2_0 L0_N1140 L1_N269 1.1683261279e+06
R_Conv_1_10_4_1_0_2_1 L0_N1141 L1_N269 1.1602008983e+05
R_Conv_1_10_4_1_1_0_0 L0_N1192 L1_N269 1.2296662853e+05
R_Conv_1_10_4_1_1_0_1 L0_N1193 L1_N269 1.6882235068e+05
R_Conv_1_10_4_1_1_1_0 L0_N1194 L1_N269 1.0472083211e+05
R_Conv_1_10_4_1_1_1_1 L0_N1195 L1_N269 2.1167619859e+05
R_Conv_1_10_4_1_1_2_0 L0_N1196 L1_N269 1.3518319025e+05
R_Conv_1_10_4_1_1_2_1 L0_N1197 L1_N269 1.4280846670e+05
R_Conv_1_10_4_1_2_0_0 L0_N1248 L1_N269 1.1620759255e+05
R_Conv_1_10_4_1_2_0_1 L0_N1249 L1_N269 1.6895116802e+05
R_Conv_1_10_4_1_2_1_0 L0_N1250 L1_N269 1.2455043512e+06
R_Conv_1_10_4_1_2_1_1 L0_N1251 L1_N269 1.1694022847e+05
R_Conv_1_10_4_1_2_2_0 L0_N1252 L1_N269 1.5663616684e+06
R_Conv_1_10_4_1_2_2_1 L0_N1253 L1_N269 2.1466641264e+05
*
R_Conv_1_10_5_0_0_0_0 L0_N1140 L1_N270 3.0927915375e+05
R_Conv_1_10_5_0_0_0_1 L0_N1141 L1_N270 3.6154472179e+05
R_Conv_1_10_5_0_0_1_0 L0_N1142 L1_N270 1.2307612303e+05
R_Conv_1_10_5_0_0_1_1 L0_N1143 L1_N270 1.3361401953e+06
R_Conv_1_10_5_0_0_2_0 L0_N1144 L1_N270 1.1771240850e+06
R_Conv_1_10_5_0_0_2_1 L0_N1145 L1_N270 1.1947062568e+05
R_Conv_1_10_5_0_1_0_0 L0_N1196 L1_N270 3.4555602430e+05
R_Conv_1_10_5_0_1_0_1 L0_N1197 L1_N270 1.2140655673e+05
R_Conv_1_10_5_0_1_1_0 L0_N1198 L1_N270 2.0024008865e+05
R_Conv_1_10_5_0_1_1_1 L0_N1199 L1_N270 1.3019124074e+05
R_Conv_1_10_5_0_1_2_0 L0_N1200 L1_N270 1.1085089352e+05
R_Conv_1_10_5_0_1_2_1 L0_N1201 L1_N270 2.5251460583e+05
R_Conv_1_10_5_0_2_0_0 L0_N1252 L1_N270 1.1040315248e+05
R_Conv_1_10_5_0_2_0_1 L0_N1253 L1_N270 1.2105931856e+05
R_Conv_1_10_5_0_2_1_0 L0_N1254 L1_N270 1.0186236681e+05
R_Conv_1_10_5_0_2_1_1 L0_N1255 L1_N270 3.8798345399e+05
R_Conv_1_10_5_0_2_2_0 L0_N1256 L1_N270 4.4022254443e+06
R_Conv_1_10_5_0_2_2_1 L0_N1257 L1_N270 1.5358515901e+05
*
R_Conv_1_10_5_1_0_0_0 L0_N1140 L1_N271 1.2123709737e+05
R_Conv_1_10_5_1_0_0_1 L0_N1141 L1_N271 1.0849154640e+05
R_Conv_1_10_5_1_0_1_0 L0_N1142 L1_N271 2.0480317885e+05
R_Conv_1_10_5_1_0_1_1 L0_N1143 L1_N271 1.6641635952e+05
R_Conv_1_10_5_1_0_2_0 L0_N1144 L1_N271 1.1683261279e+06
R_Conv_1_10_5_1_0_2_1 L0_N1145 L1_N271 1.1602008983e+05
R_Conv_1_10_5_1_1_0_0 L0_N1196 L1_N271 1.2296662853e+05
R_Conv_1_10_5_1_1_0_1 L0_N1197 L1_N271 1.6882235068e+05
R_Conv_1_10_5_1_1_1_0 L0_N1198 L1_N271 1.0472083211e+05
R_Conv_1_10_5_1_1_1_1 L0_N1199 L1_N271 2.1167619859e+05
R_Conv_1_10_5_1_1_2_0 L0_N1200 L1_N271 1.3518319025e+05
R_Conv_1_10_5_1_1_2_1 L0_N1201 L1_N271 1.4280846670e+05
R_Conv_1_10_5_1_2_0_0 L0_N1252 L1_N271 1.1620759255e+05
R_Conv_1_10_5_1_2_0_1 L0_N1253 L1_N271 1.6895116802e+05
R_Conv_1_10_5_1_2_1_0 L0_N1254 L1_N271 1.2455043512e+06
R_Conv_1_10_5_1_2_1_1 L0_N1255 L1_N271 1.1694022847e+05
R_Conv_1_10_5_1_2_2_0 L0_N1256 L1_N271 1.5663616684e+06
R_Conv_1_10_5_1_2_2_1 L0_N1257 L1_N271 2.1466641264e+05
*
R_Conv_1_10_6_0_0_0_0 L0_N1144 L1_N272 3.0927915375e+05
R_Conv_1_10_6_0_0_0_1 L0_N1145 L1_N272 3.6154472179e+05
R_Conv_1_10_6_0_0_1_0 L0_N1146 L1_N272 1.2307612303e+05
R_Conv_1_10_6_0_0_1_1 L0_N1147 L1_N272 1.3361401953e+06
R_Conv_1_10_6_0_0_2_0 L0_N1148 L1_N272 1.1771240850e+06
R_Conv_1_10_6_0_0_2_1 L0_N1149 L1_N272 1.1947062568e+05
R_Conv_1_10_6_0_1_0_0 L0_N1200 L1_N272 3.4555602430e+05
R_Conv_1_10_6_0_1_0_1 L0_N1201 L1_N272 1.2140655673e+05
R_Conv_1_10_6_0_1_1_0 L0_N1202 L1_N272 2.0024008865e+05
R_Conv_1_10_6_0_1_1_1 L0_N1203 L1_N272 1.3019124074e+05
R_Conv_1_10_6_0_1_2_0 L0_N1204 L1_N272 1.1085089352e+05
R_Conv_1_10_6_0_1_2_1 L0_N1205 L1_N272 2.5251460583e+05
R_Conv_1_10_6_0_2_0_0 L0_N1256 L1_N272 1.1040315248e+05
R_Conv_1_10_6_0_2_0_1 L0_N1257 L1_N272 1.2105931856e+05
R_Conv_1_10_6_0_2_1_0 L0_N1258 L1_N272 1.0186236681e+05
R_Conv_1_10_6_0_2_1_1 L0_N1259 L1_N272 3.8798345399e+05
R_Conv_1_10_6_0_2_2_0 L0_N1260 L1_N272 4.4022254443e+06
R_Conv_1_10_6_0_2_2_1 L0_N1261 L1_N272 1.5358515901e+05
*
R_Conv_1_10_6_1_0_0_0 L0_N1144 L1_N273 1.2123709737e+05
R_Conv_1_10_6_1_0_0_1 L0_N1145 L1_N273 1.0849154640e+05
R_Conv_1_10_6_1_0_1_0 L0_N1146 L1_N273 2.0480317885e+05
R_Conv_1_10_6_1_0_1_1 L0_N1147 L1_N273 1.6641635952e+05
R_Conv_1_10_6_1_0_2_0 L0_N1148 L1_N273 1.1683261279e+06
R_Conv_1_10_6_1_0_2_1 L0_N1149 L1_N273 1.1602008983e+05
R_Conv_1_10_6_1_1_0_0 L0_N1200 L1_N273 1.2296662853e+05
R_Conv_1_10_6_1_1_0_1 L0_N1201 L1_N273 1.6882235068e+05
R_Conv_1_10_6_1_1_1_0 L0_N1202 L1_N273 1.0472083211e+05
R_Conv_1_10_6_1_1_1_1 L0_N1203 L1_N273 2.1167619859e+05
R_Conv_1_10_6_1_1_2_0 L0_N1204 L1_N273 1.3518319025e+05
R_Conv_1_10_6_1_1_2_1 L0_N1205 L1_N273 1.4280846670e+05
R_Conv_1_10_6_1_2_0_0 L0_N1256 L1_N273 1.1620759255e+05
R_Conv_1_10_6_1_2_0_1 L0_N1257 L1_N273 1.6895116802e+05
R_Conv_1_10_6_1_2_1_0 L0_N1258 L1_N273 1.2455043512e+06
R_Conv_1_10_6_1_2_1_1 L0_N1259 L1_N273 1.1694022847e+05
R_Conv_1_10_6_1_2_2_0 L0_N1260 L1_N273 1.5663616684e+06
R_Conv_1_10_6_1_2_2_1 L0_N1261 L1_N273 2.1466641264e+05
*
R_Conv_1_10_7_0_0_0_0 L0_N1148 L1_N274 3.0927915375e+05
R_Conv_1_10_7_0_0_0_1 L0_N1149 L1_N274 3.6154472179e+05
R_Conv_1_10_7_0_0_1_0 L0_N1150 L1_N274 1.2307612303e+05
R_Conv_1_10_7_0_0_1_1 L0_N1151 L1_N274 1.3361401953e+06
R_Conv_1_10_7_0_0_2_0 L0_N1152 L1_N274 1.1771240850e+06
R_Conv_1_10_7_0_0_2_1 L0_N1153 L1_N274 1.1947062568e+05
R_Conv_1_10_7_0_1_0_0 L0_N1204 L1_N274 3.4555602430e+05
R_Conv_1_10_7_0_1_0_1 L0_N1205 L1_N274 1.2140655673e+05
R_Conv_1_10_7_0_1_1_0 L0_N1206 L1_N274 2.0024008865e+05
R_Conv_1_10_7_0_1_1_1 L0_N1207 L1_N274 1.3019124074e+05
R_Conv_1_10_7_0_1_2_0 L0_N1208 L1_N274 1.1085089352e+05
R_Conv_1_10_7_0_1_2_1 L0_N1209 L1_N274 2.5251460583e+05
R_Conv_1_10_7_0_2_0_0 L0_N1260 L1_N274 1.1040315248e+05
R_Conv_1_10_7_0_2_0_1 L0_N1261 L1_N274 1.2105931856e+05
R_Conv_1_10_7_0_2_1_0 L0_N1262 L1_N274 1.0186236681e+05
R_Conv_1_10_7_0_2_1_1 L0_N1263 L1_N274 3.8798345399e+05
R_Conv_1_10_7_0_2_2_0 L0_N1264 L1_N274 4.4022254443e+06
R_Conv_1_10_7_0_2_2_1 L0_N1265 L1_N274 1.5358515901e+05
*
R_Conv_1_10_7_1_0_0_0 L0_N1148 L1_N275 1.2123709737e+05
R_Conv_1_10_7_1_0_0_1 L0_N1149 L1_N275 1.0849154640e+05
R_Conv_1_10_7_1_0_1_0 L0_N1150 L1_N275 2.0480317885e+05
R_Conv_1_10_7_1_0_1_1 L0_N1151 L1_N275 1.6641635952e+05
R_Conv_1_10_7_1_0_2_0 L0_N1152 L1_N275 1.1683261279e+06
R_Conv_1_10_7_1_0_2_1 L0_N1153 L1_N275 1.1602008983e+05
R_Conv_1_10_7_1_1_0_0 L0_N1204 L1_N275 1.2296662853e+05
R_Conv_1_10_7_1_1_0_1 L0_N1205 L1_N275 1.6882235068e+05
R_Conv_1_10_7_1_1_1_0 L0_N1206 L1_N275 1.0472083211e+05
R_Conv_1_10_7_1_1_1_1 L0_N1207 L1_N275 2.1167619859e+05
R_Conv_1_10_7_1_1_2_0 L0_N1208 L1_N275 1.3518319025e+05
R_Conv_1_10_7_1_1_2_1 L0_N1209 L1_N275 1.4280846670e+05
R_Conv_1_10_7_1_2_0_0 L0_N1260 L1_N275 1.1620759255e+05
R_Conv_1_10_7_1_2_0_1 L0_N1261 L1_N275 1.6895116802e+05
R_Conv_1_10_7_1_2_1_0 L0_N1262 L1_N275 1.2455043512e+06
R_Conv_1_10_7_1_2_1_1 L0_N1263 L1_N275 1.1694022847e+05
R_Conv_1_10_7_1_2_2_0 L0_N1264 L1_N275 1.5663616684e+06
R_Conv_1_10_7_1_2_2_1 L0_N1265 L1_N275 2.1466641264e+05
*
R_Conv_1_10_8_0_0_0_0 L0_N1152 L1_N276 3.0927915375e+05
R_Conv_1_10_8_0_0_0_1 L0_N1153 L1_N276 3.6154472179e+05
R_Conv_1_10_8_0_0_1_0 L0_N1154 L1_N276 1.2307612303e+05
R_Conv_1_10_8_0_0_1_1 L0_N1155 L1_N276 1.3361401953e+06
R_Conv_1_10_8_0_0_2_0 L0_N1156 L1_N276 1.1771240850e+06
R_Conv_1_10_8_0_0_2_1 L0_N1157 L1_N276 1.1947062568e+05
R_Conv_1_10_8_0_1_0_0 L0_N1208 L1_N276 3.4555602430e+05
R_Conv_1_10_8_0_1_0_1 L0_N1209 L1_N276 1.2140655673e+05
R_Conv_1_10_8_0_1_1_0 L0_N1210 L1_N276 2.0024008865e+05
R_Conv_1_10_8_0_1_1_1 L0_N1211 L1_N276 1.3019124074e+05
R_Conv_1_10_8_0_1_2_0 L0_N1212 L1_N276 1.1085089352e+05
R_Conv_1_10_8_0_1_2_1 L0_N1213 L1_N276 2.5251460583e+05
R_Conv_1_10_8_0_2_0_0 L0_N1264 L1_N276 1.1040315248e+05
R_Conv_1_10_8_0_2_0_1 L0_N1265 L1_N276 1.2105931856e+05
R_Conv_1_10_8_0_2_1_0 L0_N1266 L1_N276 1.0186236681e+05
R_Conv_1_10_8_0_2_1_1 L0_N1267 L1_N276 3.8798345399e+05
R_Conv_1_10_8_0_2_2_0 L0_N1268 L1_N276 4.4022254443e+06
R_Conv_1_10_8_0_2_2_1 L0_N1269 L1_N276 1.5358515901e+05
*
R_Conv_1_10_8_1_0_0_0 L0_N1152 L1_N277 1.2123709737e+05
R_Conv_1_10_8_1_0_0_1 L0_N1153 L1_N277 1.0849154640e+05
R_Conv_1_10_8_1_0_1_0 L0_N1154 L1_N277 2.0480317885e+05
R_Conv_1_10_8_1_0_1_1 L0_N1155 L1_N277 1.6641635952e+05
R_Conv_1_10_8_1_0_2_0 L0_N1156 L1_N277 1.1683261279e+06
R_Conv_1_10_8_1_0_2_1 L0_N1157 L1_N277 1.1602008983e+05
R_Conv_1_10_8_1_1_0_0 L0_N1208 L1_N277 1.2296662853e+05
R_Conv_1_10_8_1_1_0_1 L0_N1209 L1_N277 1.6882235068e+05
R_Conv_1_10_8_1_1_1_0 L0_N1210 L1_N277 1.0472083211e+05
R_Conv_1_10_8_1_1_1_1 L0_N1211 L1_N277 2.1167619859e+05
R_Conv_1_10_8_1_1_2_0 L0_N1212 L1_N277 1.3518319025e+05
R_Conv_1_10_8_1_1_2_1 L0_N1213 L1_N277 1.4280846670e+05
R_Conv_1_10_8_1_2_0_0 L0_N1264 L1_N277 1.1620759255e+05
R_Conv_1_10_8_1_2_0_1 L0_N1265 L1_N277 1.6895116802e+05
R_Conv_1_10_8_1_2_1_0 L0_N1266 L1_N277 1.2455043512e+06
R_Conv_1_10_8_1_2_1_1 L0_N1267 L1_N277 1.1694022847e+05
R_Conv_1_10_8_1_2_2_0 L0_N1268 L1_N277 1.5663616684e+06
R_Conv_1_10_8_1_2_2_1 L0_N1269 L1_N277 2.1466641264e+05
*
R_Conv_1_10_9_0_0_0_0 L0_N1156 L1_N278 3.0927915375e+05
R_Conv_1_10_9_0_0_0_1 L0_N1157 L1_N278 3.6154472179e+05
R_Conv_1_10_9_0_0_1_0 L0_N1158 L1_N278 1.2307612303e+05
R_Conv_1_10_9_0_0_1_1 L0_N1159 L1_N278 1.3361401953e+06
R_Conv_1_10_9_0_0_2_0 L0_N1160 L1_N278 1.1771240850e+06
R_Conv_1_10_9_0_0_2_1 L0_N1161 L1_N278 1.1947062568e+05
R_Conv_1_10_9_0_1_0_0 L0_N1212 L1_N278 3.4555602430e+05
R_Conv_1_10_9_0_1_0_1 L0_N1213 L1_N278 1.2140655673e+05
R_Conv_1_10_9_0_1_1_0 L0_N1214 L1_N278 2.0024008865e+05
R_Conv_1_10_9_0_1_1_1 L0_N1215 L1_N278 1.3019124074e+05
R_Conv_1_10_9_0_1_2_0 L0_N1216 L1_N278 1.1085089352e+05
R_Conv_1_10_9_0_1_2_1 L0_N1217 L1_N278 2.5251460583e+05
R_Conv_1_10_9_0_2_0_0 L0_N1268 L1_N278 1.1040315248e+05
R_Conv_1_10_9_0_2_0_1 L0_N1269 L1_N278 1.2105931856e+05
R_Conv_1_10_9_0_2_1_0 L0_N1270 L1_N278 1.0186236681e+05
R_Conv_1_10_9_0_2_1_1 L0_N1271 L1_N278 3.8798345399e+05
R_Conv_1_10_9_0_2_2_0 L0_N1272 L1_N278 4.4022254443e+06
R_Conv_1_10_9_0_2_2_1 L0_N1273 L1_N278 1.5358515901e+05
*
R_Conv_1_10_9_1_0_0_0 L0_N1156 L1_N279 1.2123709737e+05
R_Conv_1_10_9_1_0_0_1 L0_N1157 L1_N279 1.0849154640e+05
R_Conv_1_10_9_1_0_1_0 L0_N1158 L1_N279 2.0480317885e+05
R_Conv_1_10_9_1_0_1_1 L0_N1159 L1_N279 1.6641635952e+05
R_Conv_1_10_9_1_0_2_0 L0_N1160 L1_N279 1.1683261279e+06
R_Conv_1_10_9_1_0_2_1 L0_N1161 L1_N279 1.1602008983e+05
R_Conv_1_10_9_1_1_0_0 L0_N1212 L1_N279 1.2296662853e+05
R_Conv_1_10_9_1_1_0_1 L0_N1213 L1_N279 1.6882235068e+05
R_Conv_1_10_9_1_1_1_0 L0_N1214 L1_N279 1.0472083211e+05
R_Conv_1_10_9_1_1_1_1 L0_N1215 L1_N279 2.1167619859e+05
R_Conv_1_10_9_1_1_2_0 L0_N1216 L1_N279 1.3518319025e+05
R_Conv_1_10_9_1_1_2_1 L0_N1217 L1_N279 1.4280846670e+05
R_Conv_1_10_9_1_2_0_0 L0_N1268 L1_N279 1.1620759255e+05
R_Conv_1_10_9_1_2_0_1 L0_N1269 L1_N279 1.6895116802e+05
R_Conv_1_10_9_1_2_1_0 L0_N1270 L1_N279 1.2455043512e+06
R_Conv_1_10_9_1_2_1_1 L0_N1271 L1_N279 1.1694022847e+05
R_Conv_1_10_9_1_2_2_0 L0_N1272 L1_N279 1.5663616684e+06
R_Conv_1_10_9_1_2_2_1 L0_N1273 L1_N279 2.1466641264e+05
*
R_Conv_1_10_10_0_0_0_0 L0_N1160 L1_N280 3.0927915375e+05
R_Conv_1_10_10_0_0_0_1 L0_N1161 L1_N280 3.6154472179e+05
R_Conv_1_10_10_0_0_1_0 L0_N1162 L1_N280 1.2307612303e+05
R_Conv_1_10_10_0_0_1_1 L0_N1163 L1_N280 1.3361401953e+06
R_Conv_1_10_10_0_0_2_0 L0_N1164 L1_N280 1.1771240850e+06
R_Conv_1_10_10_0_0_2_1 L0_N1165 L1_N280 1.1947062568e+05
R_Conv_1_10_10_0_1_0_0 L0_N1216 L1_N280 3.4555602430e+05
R_Conv_1_10_10_0_1_0_1 L0_N1217 L1_N280 1.2140655673e+05
R_Conv_1_10_10_0_1_1_0 L0_N1218 L1_N280 2.0024008865e+05
R_Conv_1_10_10_0_1_1_1 L0_N1219 L1_N280 1.3019124074e+05
R_Conv_1_10_10_0_1_2_0 L0_N1220 L1_N280 1.1085089352e+05
R_Conv_1_10_10_0_1_2_1 L0_N1221 L1_N280 2.5251460583e+05
R_Conv_1_10_10_0_2_0_0 L0_N1272 L1_N280 1.1040315248e+05
R_Conv_1_10_10_0_2_0_1 L0_N1273 L1_N280 1.2105931856e+05
R_Conv_1_10_10_0_2_1_0 L0_N1274 L1_N280 1.0186236681e+05
R_Conv_1_10_10_0_2_1_1 L0_N1275 L1_N280 3.8798345399e+05
R_Conv_1_10_10_0_2_2_0 L0_N1276 L1_N280 4.4022254443e+06
R_Conv_1_10_10_0_2_2_1 L0_N1277 L1_N280 1.5358515901e+05
*
R_Conv_1_10_10_1_0_0_0 L0_N1160 L1_N281 1.2123709737e+05
R_Conv_1_10_10_1_0_0_1 L0_N1161 L1_N281 1.0849154640e+05
R_Conv_1_10_10_1_0_1_0 L0_N1162 L1_N281 2.0480317885e+05
R_Conv_1_10_10_1_0_1_1 L0_N1163 L1_N281 1.6641635952e+05
R_Conv_1_10_10_1_0_2_0 L0_N1164 L1_N281 1.1683261279e+06
R_Conv_1_10_10_1_0_2_1 L0_N1165 L1_N281 1.1602008983e+05
R_Conv_1_10_10_1_1_0_0 L0_N1216 L1_N281 1.2296662853e+05
R_Conv_1_10_10_1_1_0_1 L0_N1217 L1_N281 1.6882235068e+05
R_Conv_1_10_10_1_1_1_0 L0_N1218 L1_N281 1.0472083211e+05
R_Conv_1_10_10_1_1_1_1 L0_N1219 L1_N281 2.1167619859e+05
R_Conv_1_10_10_1_1_2_0 L0_N1220 L1_N281 1.3518319025e+05
R_Conv_1_10_10_1_1_2_1 L0_N1221 L1_N281 1.4280846670e+05
R_Conv_1_10_10_1_2_0_0 L0_N1272 L1_N281 1.1620759255e+05
R_Conv_1_10_10_1_2_0_1 L0_N1273 L1_N281 1.6895116802e+05
R_Conv_1_10_10_1_2_1_0 L0_N1274 L1_N281 1.2455043512e+06
R_Conv_1_10_10_1_2_1_1 L0_N1275 L1_N281 1.1694022847e+05
R_Conv_1_10_10_1_2_2_0 L0_N1276 L1_N281 1.5663616684e+06
R_Conv_1_10_10_1_2_2_1 L0_N1277 L1_N281 2.1466641264e+05
*
R_Conv_1_10_11_0_0_0_0 L0_N1164 L1_N282 3.0927915375e+05
R_Conv_1_10_11_0_0_0_1 L0_N1165 L1_N282 3.6154472179e+05
R_Conv_1_10_11_0_0_1_0 L0_N1166 L1_N282 1.2307612303e+05
R_Conv_1_10_11_0_0_1_1 L0_N1167 L1_N282 1.3361401953e+06
R_Conv_1_10_11_0_0_2_0 L0_N1168 L1_N282 1.1771240850e+06
R_Conv_1_10_11_0_0_2_1 L0_N1169 L1_N282 1.1947062568e+05
R_Conv_1_10_11_0_1_0_0 L0_N1220 L1_N282 3.4555602430e+05
R_Conv_1_10_11_0_1_0_1 L0_N1221 L1_N282 1.2140655673e+05
R_Conv_1_10_11_0_1_1_0 L0_N1222 L1_N282 2.0024008865e+05
R_Conv_1_10_11_0_1_1_1 L0_N1223 L1_N282 1.3019124074e+05
R_Conv_1_10_11_0_1_2_0 L0_N1224 L1_N282 1.1085089352e+05
R_Conv_1_10_11_0_1_2_1 L0_N1225 L1_N282 2.5251460583e+05
R_Conv_1_10_11_0_2_0_0 L0_N1276 L1_N282 1.1040315248e+05
R_Conv_1_10_11_0_2_0_1 L0_N1277 L1_N282 1.2105931856e+05
R_Conv_1_10_11_0_2_1_0 L0_N1278 L1_N282 1.0186236681e+05
R_Conv_1_10_11_0_2_1_1 L0_N1279 L1_N282 3.8798345399e+05
R_Conv_1_10_11_0_2_2_0 L0_N1280 L1_N282 4.4022254443e+06
R_Conv_1_10_11_0_2_2_1 L0_N1281 L1_N282 1.5358515901e+05
*
R_Conv_1_10_11_1_0_0_0 L0_N1164 L1_N283 1.2123709737e+05
R_Conv_1_10_11_1_0_0_1 L0_N1165 L1_N283 1.0849154640e+05
R_Conv_1_10_11_1_0_1_0 L0_N1166 L1_N283 2.0480317885e+05
R_Conv_1_10_11_1_0_1_1 L0_N1167 L1_N283 1.6641635952e+05
R_Conv_1_10_11_1_0_2_0 L0_N1168 L1_N283 1.1683261279e+06
R_Conv_1_10_11_1_0_2_1 L0_N1169 L1_N283 1.1602008983e+05
R_Conv_1_10_11_1_1_0_0 L0_N1220 L1_N283 1.2296662853e+05
R_Conv_1_10_11_1_1_0_1 L0_N1221 L1_N283 1.6882235068e+05
R_Conv_1_10_11_1_1_1_0 L0_N1222 L1_N283 1.0472083211e+05
R_Conv_1_10_11_1_1_1_1 L0_N1223 L1_N283 2.1167619859e+05
R_Conv_1_10_11_1_1_2_0 L0_N1224 L1_N283 1.3518319025e+05
R_Conv_1_10_11_1_1_2_1 L0_N1225 L1_N283 1.4280846670e+05
R_Conv_1_10_11_1_2_0_0 L0_N1276 L1_N283 1.1620759255e+05
R_Conv_1_10_11_1_2_0_1 L0_N1277 L1_N283 1.6895116802e+05
R_Conv_1_10_11_1_2_1_0 L0_N1278 L1_N283 1.2455043512e+06
R_Conv_1_10_11_1_2_1_1 L0_N1279 L1_N283 1.1694022847e+05
R_Conv_1_10_11_1_2_2_0 L0_N1280 L1_N283 1.5663616684e+06
R_Conv_1_10_11_1_2_2_1 L0_N1281 L1_N283 2.1466641264e+05
*
R_Conv_1_10_12_0_0_0_0 L0_N1168 L1_N284 3.0927915375e+05
R_Conv_1_10_12_0_0_0_1 L0_N1169 L1_N284 3.6154472179e+05
R_Conv_1_10_12_0_0_1_0 L0_N1170 L1_N284 1.2307612303e+05
R_Conv_1_10_12_0_0_1_1 L0_N1171 L1_N284 1.3361401953e+06
R_Conv_1_10_12_0_0_2_0 L0_N1172 L1_N284 1.1771240850e+06
R_Conv_1_10_12_0_0_2_1 L0_N1173 L1_N284 1.1947062568e+05
R_Conv_1_10_12_0_1_0_0 L0_N1224 L1_N284 3.4555602430e+05
R_Conv_1_10_12_0_1_0_1 L0_N1225 L1_N284 1.2140655673e+05
R_Conv_1_10_12_0_1_1_0 L0_N1226 L1_N284 2.0024008865e+05
R_Conv_1_10_12_0_1_1_1 L0_N1227 L1_N284 1.3019124074e+05
R_Conv_1_10_12_0_1_2_0 L0_N1228 L1_N284 1.1085089352e+05
R_Conv_1_10_12_0_1_2_1 L0_N1229 L1_N284 2.5251460583e+05
R_Conv_1_10_12_0_2_0_0 L0_N1280 L1_N284 1.1040315248e+05
R_Conv_1_10_12_0_2_0_1 L0_N1281 L1_N284 1.2105931856e+05
R_Conv_1_10_12_0_2_1_0 L0_N1282 L1_N284 1.0186236681e+05
R_Conv_1_10_12_0_2_1_1 L0_N1283 L1_N284 3.8798345399e+05
R_Conv_1_10_12_0_2_2_0 L0_N1284 L1_N284 4.4022254443e+06
R_Conv_1_10_12_0_2_2_1 L0_N1285 L1_N284 1.5358515901e+05
*
R_Conv_1_10_12_1_0_0_0 L0_N1168 L1_N285 1.2123709737e+05
R_Conv_1_10_12_1_0_0_1 L0_N1169 L1_N285 1.0849154640e+05
R_Conv_1_10_12_1_0_1_0 L0_N1170 L1_N285 2.0480317885e+05
R_Conv_1_10_12_1_0_1_1 L0_N1171 L1_N285 1.6641635952e+05
R_Conv_1_10_12_1_0_2_0 L0_N1172 L1_N285 1.1683261279e+06
R_Conv_1_10_12_1_0_2_1 L0_N1173 L1_N285 1.1602008983e+05
R_Conv_1_10_12_1_1_0_0 L0_N1224 L1_N285 1.2296662853e+05
R_Conv_1_10_12_1_1_0_1 L0_N1225 L1_N285 1.6882235068e+05
R_Conv_1_10_12_1_1_1_0 L0_N1226 L1_N285 1.0472083211e+05
R_Conv_1_10_12_1_1_1_1 L0_N1227 L1_N285 2.1167619859e+05
R_Conv_1_10_12_1_1_2_0 L0_N1228 L1_N285 1.3518319025e+05
R_Conv_1_10_12_1_1_2_1 L0_N1229 L1_N285 1.4280846670e+05
R_Conv_1_10_12_1_2_0_0 L0_N1280 L1_N285 1.1620759255e+05
R_Conv_1_10_12_1_2_0_1 L0_N1281 L1_N285 1.6895116802e+05
R_Conv_1_10_12_1_2_1_0 L0_N1282 L1_N285 1.2455043512e+06
R_Conv_1_10_12_1_2_1_1 L0_N1283 L1_N285 1.1694022847e+05
R_Conv_1_10_12_1_2_2_0 L0_N1284 L1_N285 1.5663616684e+06
R_Conv_1_10_12_1_2_2_1 L0_N1285 L1_N285 2.1466641264e+05
*
R_Conv_1_11_0_0_0_0_0 L0_N1232 L1_N286 3.0927915375e+05
R_Conv_1_11_0_0_0_0_1 L0_N1233 L1_N286 3.6154472179e+05
R_Conv_1_11_0_0_0_1_0 L0_N1234 L1_N286 1.2307612303e+05
R_Conv_1_11_0_0_0_1_1 L0_N1235 L1_N286 1.3361401953e+06
R_Conv_1_11_0_0_0_2_0 L0_N1236 L1_N286 1.1771240850e+06
R_Conv_1_11_0_0_0_2_1 L0_N1237 L1_N286 1.1947062568e+05
R_Conv_1_11_0_0_1_0_0 L0_N1288 L1_N286 3.4555602430e+05
R_Conv_1_11_0_0_1_0_1 L0_N1289 L1_N286 1.2140655673e+05
R_Conv_1_11_0_0_1_1_0 L0_N1290 L1_N286 2.0024008865e+05
R_Conv_1_11_0_0_1_1_1 L0_N1291 L1_N286 1.3019124074e+05
R_Conv_1_11_0_0_1_2_0 L0_N1292 L1_N286 1.1085089352e+05
R_Conv_1_11_0_0_1_2_1 L0_N1293 L1_N286 2.5251460583e+05
R_Conv_1_11_0_0_2_0_0 L0_N1344 L1_N286 1.1040315248e+05
R_Conv_1_11_0_0_2_0_1 L0_N1345 L1_N286 1.2105931856e+05
R_Conv_1_11_0_0_2_1_0 L0_N1346 L1_N286 1.0186236681e+05
R_Conv_1_11_0_0_2_1_1 L0_N1347 L1_N286 3.8798345399e+05
R_Conv_1_11_0_0_2_2_0 L0_N1348 L1_N286 4.4022254443e+06
R_Conv_1_11_0_0_2_2_1 L0_N1349 L1_N286 1.5358515901e+05
*
R_Conv_1_11_0_1_0_0_0 L0_N1232 L1_N287 1.2123709737e+05
R_Conv_1_11_0_1_0_0_1 L0_N1233 L1_N287 1.0849154640e+05
R_Conv_1_11_0_1_0_1_0 L0_N1234 L1_N287 2.0480317885e+05
R_Conv_1_11_0_1_0_1_1 L0_N1235 L1_N287 1.6641635952e+05
R_Conv_1_11_0_1_0_2_0 L0_N1236 L1_N287 1.1683261279e+06
R_Conv_1_11_0_1_0_2_1 L0_N1237 L1_N287 1.1602008983e+05
R_Conv_1_11_0_1_1_0_0 L0_N1288 L1_N287 1.2296662853e+05
R_Conv_1_11_0_1_1_0_1 L0_N1289 L1_N287 1.6882235068e+05
R_Conv_1_11_0_1_1_1_0 L0_N1290 L1_N287 1.0472083211e+05
R_Conv_1_11_0_1_1_1_1 L0_N1291 L1_N287 2.1167619859e+05
R_Conv_1_11_0_1_1_2_0 L0_N1292 L1_N287 1.3518319025e+05
R_Conv_1_11_0_1_1_2_1 L0_N1293 L1_N287 1.4280846670e+05
R_Conv_1_11_0_1_2_0_0 L0_N1344 L1_N287 1.1620759255e+05
R_Conv_1_11_0_1_2_0_1 L0_N1345 L1_N287 1.6895116802e+05
R_Conv_1_11_0_1_2_1_0 L0_N1346 L1_N287 1.2455043512e+06
R_Conv_1_11_0_1_2_1_1 L0_N1347 L1_N287 1.1694022847e+05
R_Conv_1_11_0_1_2_2_0 L0_N1348 L1_N287 1.5663616684e+06
R_Conv_1_11_0_1_2_2_1 L0_N1349 L1_N287 2.1466641264e+05
*
R_Conv_1_11_1_0_0_0_0 L0_N1236 L1_N288 3.0927915375e+05
R_Conv_1_11_1_0_0_0_1 L0_N1237 L1_N288 3.6154472179e+05
R_Conv_1_11_1_0_0_1_0 L0_N1238 L1_N288 1.2307612303e+05
R_Conv_1_11_1_0_0_1_1 L0_N1239 L1_N288 1.3361401953e+06
R_Conv_1_11_1_0_0_2_0 L0_N1240 L1_N288 1.1771240850e+06
R_Conv_1_11_1_0_0_2_1 L0_N1241 L1_N288 1.1947062568e+05
R_Conv_1_11_1_0_1_0_0 L0_N1292 L1_N288 3.4555602430e+05
R_Conv_1_11_1_0_1_0_1 L0_N1293 L1_N288 1.2140655673e+05
R_Conv_1_11_1_0_1_1_0 L0_N1294 L1_N288 2.0024008865e+05
R_Conv_1_11_1_0_1_1_1 L0_N1295 L1_N288 1.3019124074e+05
R_Conv_1_11_1_0_1_2_0 L0_N1296 L1_N288 1.1085089352e+05
R_Conv_1_11_1_0_1_2_1 L0_N1297 L1_N288 2.5251460583e+05
R_Conv_1_11_1_0_2_0_0 L0_N1348 L1_N288 1.1040315248e+05
R_Conv_1_11_1_0_2_0_1 L0_N1349 L1_N288 1.2105931856e+05
R_Conv_1_11_1_0_2_1_0 L0_N1350 L1_N288 1.0186236681e+05
R_Conv_1_11_1_0_2_1_1 L0_N1351 L1_N288 3.8798345399e+05
R_Conv_1_11_1_0_2_2_0 L0_N1352 L1_N288 4.4022254443e+06
R_Conv_1_11_1_0_2_2_1 L0_N1353 L1_N288 1.5358515901e+05
*
R_Conv_1_11_1_1_0_0_0 L0_N1236 L1_N289 1.2123709737e+05
R_Conv_1_11_1_1_0_0_1 L0_N1237 L1_N289 1.0849154640e+05
R_Conv_1_11_1_1_0_1_0 L0_N1238 L1_N289 2.0480317885e+05
R_Conv_1_11_1_1_0_1_1 L0_N1239 L1_N289 1.6641635952e+05
R_Conv_1_11_1_1_0_2_0 L0_N1240 L1_N289 1.1683261279e+06
R_Conv_1_11_1_1_0_2_1 L0_N1241 L1_N289 1.1602008983e+05
R_Conv_1_11_1_1_1_0_0 L0_N1292 L1_N289 1.2296662853e+05
R_Conv_1_11_1_1_1_0_1 L0_N1293 L1_N289 1.6882235068e+05
R_Conv_1_11_1_1_1_1_0 L0_N1294 L1_N289 1.0472083211e+05
R_Conv_1_11_1_1_1_1_1 L0_N1295 L1_N289 2.1167619859e+05
R_Conv_1_11_1_1_1_2_0 L0_N1296 L1_N289 1.3518319025e+05
R_Conv_1_11_1_1_1_2_1 L0_N1297 L1_N289 1.4280846670e+05
R_Conv_1_11_1_1_2_0_0 L0_N1348 L1_N289 1.1620759255e+05
R_Conv_1_11_1_1_2_0_1 L0_N1349 L1_N289 1.6895116802e+05
R_Conv_1_11_1_1_2_1_0 L0_N1350 L1_N289 1.2455043512e+06
R_Conv_1_11_1_1_2_1_1 L0_N1351 L1_N289 1.1694022847e+05
R_Conv_1_11_1_1_2_2_0 L0_N1352 L1_N289 1.5663616684e+06
R_Conv_1_11_1_1_2_2_1 L0_N1353 L1_N289 2.1466641264e+05
*
R_Conv_1_11_2_0_0_0_0 L0_N1240 L1_N290 3.0927915375e+05
R_Conv_1_11_2_0_0_0_1 L0_N1241 L1_N290 3.6154472179e+05
R_Conv_1_11_2_0_0_1_0 L0_N1242 L1_N290 1.2307612303e+05
R_Conv_1_11_2_0_0_1_1 L0_N1243 L1_N290 1.3361401953e+06
R_Conv_1_11_2_0_0_2_0 L0_N1244 L1_N290 1.1771240850e+06
R_Conv_1_11_2_0_0_2_1 L0_N1245 L1_N290 1.1947062568e+05
R_Conv_1_11_2_0_1_0_0 L0_N1296 L1_N290 3.4555602430e+05
R_Conv_1_11_2_0_1_0_1 L0_N1297 L1_N290 1.2140655673e+05
R_Conv_1_11_2_0_1_1_0 L0_N1298 L1_N290 2.0024008865e+05
R_Conv_1_11_2_0_1_1_1 L0_N1299 L1_N290 1.3019124074e+05
R_Conv_1_11_2_0_1_2_0 L0_N1300 L1_N290 1.1085089352e+05
R_Conv_1_11_2_0_1_2_1 L0_N1301 L1_N290 2.5251460583e+05
R_Conv_1_11_2_0_2_0_0 L0_N1352 L1_N290 1.1040315248e+05
R_Conv_1_11_2_0_2_0_1 L0_N1353 L1_N290 1.2105931856e+05
R_Conv_1_11_2_0_2_1_0 L0_N1354 L1_N290 1.0186236681e+05
R_Conv_1_11_2_0_2_1_1 L0_N1355 L1_N290 3.8798345399e+05
R_Conv_1_11_2_0_2_2_0 L0_N1356 L1_N290 4.4022254443e+06
R_Conv_1_11_2_0_2_2_1 L0_N1357 L1_N290 1.5358515901e+05
*
R_Conv_1_11_2_1_0_0_0 L0_N1240 L1_N291 1.2123709737e+05
R_Conv_1_11_2_1_0_0_1 L0_N1241 L1_N291 1.0849154640e+05
R_Conv_1_11_2_1_0_1_0 L0_N1242 L1_N291 2.0480317885e+05
R_Conv_1_11_2_1_0_1_1 L0_N1243 L1_N291 1.6641635952e+05
R_Conv_1_11_2_1_0_2_0 L0_N1244 L1_N291 1.1683261279e+06
R_Conv_1_11_2_1_0_2_1 L0_N1245 L1_N291 1.1602008983e+05
R_Conv_1_11_2_1_1_0_0 L0_N1296 L1_N291 1.2296662853e+05
R_Conv_1_11_2_1_1_0_1 L0_N1297 L1_N291 1.6882235068e+05
R_Conv_1_11_2_1_1_1_0 L0_N1298 L1_N291 1.0472083211e+05
R_Conv_1_11_2_1_1_1_1 L0_N1299 L1_N291 2.1167619859e+05
R_Conv_1_11_2_1_1_2_0 L0_N1300 L1_N291 1.3518319025e+05
R_Conv_1_11_2_1_1_2_1 L0_N1301 L1_N291 1.4280846670e+05
R_Conv_1_11_2_1_2_0_0 L0_N1352 L1_N291 1.1620759255e+05
R_Conv_1_11_2_1_2_0_1 L0_N1353 L1_N291 1.6895116802e+05
R_Conv_1_11_2_1_2_1_0 L0_N1354 L1_N291 1.2455043512e+06
R_Conv_1_11_2_1_2_1_1 L0_N1355 L1_N291 1.1694022847e+05
R_Conv_1_11_2_1_2_2_0 L0_N1356 L1_N291 1.5663616684e+06
R_Conv_1_11_2_1_2_2_1 L0_N1357 L1_N291 2.1466641264e+05
*
R_Conv_1_11_3_0_0_0_0 L0_N1244 L1_N292 3.0927915375e+05
R_Conv_1_11_3_0_0_0_1 L0_N1245 L1_N292 3.6154472179e+05
R_Conv_1_11_3_0_0_1_0 L0_N1246 L1_N292 1.2307612303e+05
R_Conv_1_11_3_0_0_1_1 L0_N1247 L1_N292 1.3361401953e+06
R_Conv_1_11_3_0_0_2_0 L0_N1248 L1_N292 1.1771240850e+06
R_Conv_1_11_3_0_0_2_1 L0_N1249 L1_N292 1.1947062568e+05
R_Conv_1_11_3_0_1_0_0 L0_N1300 L1_N292 3.4555602430e+05
R_Conv_1_11_3_0_1_0_1 L0_N1301 L1_N292 1.2140655673e+05
R_Conv_1_11_3_0_1_1_0 L0_N1302 L1_N292 2.0024008865e+05
R_Conv_1_11_3_0_1_1_1 L0_N1303 L1_N292 1.3019124074e+05
R_Conv_1_11_3_0_1_2_0 L0_N1304 L1_N292 1.1085089352e+05
R_Conv_1_11_3_0_1_2_1 L0_N1305 L1_N292 2.5251460583e+05
R_Conv_1_11_3_0_2_0_0 L0_N1356 L1_N292 1.1040315248e+05
R_Conv_1_11_3_0_2_0_1 L0_N1357 L1_N292 1.2105931856e+05
R_Conv_1_11_3_0_2_1_0 L0_N1358 L1_N292 1.0186236681e+05
R_Conv_1_11_3_0_2_1_1 L0_N1359 L1_N292 3.8798345399e+05
R_Conv_1_11_3_0_2_2_0 L0_N1360 L1_N292 4.4022254443e+06
R_Conv_1_11_3_0_2_2_1 L0_N1361 L1_N292 1.5358515901e+05
*
R_Conv_1_11_3_1_0_0_0 L0_N1244 L1_N293 1.2123709737e+05
R_Conv_1_11_3_1_0_0_1 L0_N1245 L1_N293 1.0849154640e+05
R_Conv_1_11_3_1_0_1_0 L0_N1246 L1_N293 2.0480317885e+05
R_Conv_1_11_3_1_0_1_1 L0_N1247 L1_N293 1.6641635952e+05
R_Conv_1_11_3_1_0_2_0 L0_N1248 L1_N293 1.1683261279e+06
R_Conv_1_11_3_1_0_2_1 L0_N1249 L1_N293 1.1602008983e+05
R_Conv_1_11_3_1_1_0_0 L0_N1300 L1_N293 1.2296662853e+05
R_Conv_1_11_3_1_1_0_1 L0_N1301 L1_N293 1.6882235068e+05
R_Conv_1_11_3_1_1_1_0 L0_N1302 L1_N293 1.0472083211e+05
R_Conv_1_11_3_1_1_1_1 L0_N1303 L1_N293 2.1167619859e+05
R_Conv_1_11_3_1_1_2_0 L0_N1304 L1_N293 1.3518319025e+05
R_Conv_1_11_3_1_1_2_1 L0_N1305 L1_N293 1.4280846670e+05
R_Conv_1_11_3_1_2_0_0 L0_N1356 L1_N293 1.1620759255e+05
R_Conv_1_11_3_1_2_0_1 L0_N1357 L1_N293 1.6895116802e+05
R_Conv_1_11_3_1_2_1_0 L0_N1358 L1_N293 1.2455043512e+06
R_Conv_1_11_3_1_2_1_1 L0_N1359 L1_N293 1.1694022847e+05
R_Conv_1_11_3_1_2_2_0 L0_N1360 L1_N293 1.5663616684e+06
R_Conv_1_11_3_1_2_2_1 L0_N1361 L1_N293 2.1466641264e+05
*
R_Conv_1_11_4_0_0_0_0 L0_N1248 L1_N294 3.0927915375e+05
R_Conv_1_11_4_0_0_0_1 L0_N1249 L1_N294 3.6154472179e+05
R_Conv_1_11_4_0_0_1_0 L0_N1250 L1_N294 1.2307612303e+05
R_Conv_1_11_4_0_0_1_1 L0_N1251 L1_N294 1.3361401953e+06
R_Conv_1_11_4_0_0_2_0 L0_N1252 L1_N294 1.1771240850e+06
R_Conv_1_11_4_0_0_2_1 L0_N1253 L1_N294 1.1947062568e+05
R_Conv_1_11_4_0_1_0_0 L0_N1304 L1_N294 3.4555602430e+05
R_Conv_1_11_4_0_1_0_1 L0_N1305 L1_N294 1.2140655673e+05
R_Conv_1_11_4_0_1_1_0 L0_N1306 L1_N294 2.0024008865e+05
R_Conv_1_11_4_0_1_1_1 L0_N1307 L1_N294 1.3019124074e+05
R_Conv_1_11_4_0_1_2_0 L0_N1308 L1_N294 1.1085089352e+05
R_Conv_1_11_4_0_1_2_1 L0_N1309 L1_N294 2.5251460583e+05
R_Conv_1_11_4_0_2_0_0 L0_N1360 L1_N294 1.1040315248e+05
R_Conv_1_11_4_0_2_0_1 L0_N1361 L1_N294 1.2105931856e+05
R_Conv_1_11_4_0_2_1_0 L0_N1362 L1_N294 1.0186236681e+05
R_Conv_1_11_4_0_2_1_1 L0_N1363 L1_N294 3.8798345399e+05
R_Conv_1_11_4_0_2_2_0 L0_N1364 L1_N294 4.4022254443e+06
R_Conv_1_11_4_0_2_2_1 L0_N1365 L1_N294 1.5358515901e+05
*
R_Conv_1_11_4_1_0_0_0 L0_N1248 L1_N295 1.2123709737e+05
R_Conv_1_11_4_1_0_0_1 L0_N1249 L1_N295 1.0849154640e+05
R_Conv_1_11_4_1_0_1_0 L0_N1250 L1_N295 2.0480317885e+05
R_Conv_1_11_4_1_0_1_1 L0_N1251 L1_N295 1.6641635952e+05
R_Conv_1_11_4_1_0_2_0 L0_N1252 L1_N295 1.1683261279e+06
R_Conv_1_11_4_1_0_2_1 L0_N1253 L1_N295 1.1602008983e+05
R_Conv_1_11_4_1_1_0_0 L0_N1304 L1_N295 1.2296662853e+05
R_Conv_1_11_4_1_1_0_1 L0_N1305 L1_N295 1.6882235068e+05
R_Conv_1_11_4_1_1_1_0 L0_N1306 L1_N295 1.0472083211e+05
R_Conv_1_11_4_1_1_1_1 L0_N1307 L1_N295 2.1167619859e+05
R_Conv_1_11_4_1_1_2_0 L0_N1308 L1_N295 1.3518319025e+05
R_Conv_1_11_4_1_1_2_1 L0_N1309 L1_N295 1.4280846670e+05
R_Conv_1_11_4_1_2_0_0 L0_N1360 L1_N295 1.1620759255e+05
R_Conv_1_11_4_1_2_0_1 L0_N1361 L1_N295 1.6895116802e+05
R_Conv_1_11_4_1_2_1_0 L0_N1362 L1_N295 1.2455043512e+06
R_Conv_1_11_4_1_2_1_1 L0_N1363 L1_N295 1.1694022847e+05
R_Conv_1_11_4_1_2_2_0 L0_N1364 L1_N295 1.5663616684e+06
R_Conv_1_11_4_1_2_2_1 L0_N1365 L1_N295 2.1466641264e+05
*
R_Conv_1_11_5_0_0_0_0 L0_N1252 L1_N296 3.0927915375e+05
R_Conv_1_11_5_0_0_0_1 L0_N1253 L1_N296 3.6154472179e+05
R_Conv_1_11_5_0_0_1_0 L0_N1254 L1_N296 1.2307612303e+05
R_Conv_1_11_5_0_0_1_1 L0_N1255 L1_N296 1.3361401953e+06
R_Conv_1_11_5_0_0_2_0 L0_N1256 L1_N296 1.1771240850e+06
R_Conv_1_11_5_0_0_2_1 L0_N1257 L1_N296 1.1947062568e+05
R_Conv_1_11_5_0_1_0_0 L0_N1308 L1_N296 3.4555602430e+05
R_Conv_1_11_5_0_1_0_1 L0_N1309 L1_N296 1.2140655673e+05
R_Conv_1_11_5_0_1_1_0 L0_N1310 L1_N296 2.0024008865e+05
R_Conv_1_11_5_0_1_1_1 L0_N1311 L1_N296 1.3019124074e+05
R_Conv_1_11_5_0_1_2_0 L0_N1312 L1_N296 1.1085089352e+05
R_Conv_1_11_5_0_1_2_1 L0_N1313 L1_N296 2.5251460583e+05
R_Conv_1_11_5_0_2_0_0 L0_N1364 L1_N296 1.1040315248e+05
R_Conv_1_11_5_0_2_0_1 L0_N1365 L1_N296 1.2105931856e+05
R_Conv_1_11_5_0_2_1_0 L0_N1366 L1_N296 1.0186236681e+05
R_Conv_1_11_5_0_2_1_1 L0_N1367 L1_N296 3.8798345399e+05
R_Conv_1_11_5_0_2_2_0 L0_N1368 L1_N296 4.4022254443e+06
R_Conv_1_11_5_0_2_2_1 L0_N1369 L1_N296 1.5358515901e+05
*
R_Conv_1_11_5_1_0_0_0 L0_N1252 L1_N297 1.2123709737e+05
R_Conv_1_11_5_1_0_0_1 L0_N1253 L1_N297 1.0849154640e+05
R_Conv_1_11_5_1_0_1_0 L0_N1254 L1_N297 2.0480317885e+05
R_Conv_1_11_5_1_0_1_1 L0_N1255 L1_N297 1.6641635952e+05
R_Conv_1_11_5_1_0_2_0 L0_N1256 L1_N297 1.1683261279e+06
R_Conv_1_11_5_1_0_2_1 L0_N1257 L1_N297 1.1602008983e+05
R_Conv_1_11_5_1_1_0_0 L0_N1308 L1_N297 1.2296662853e+05
R_Conv_1_11_5_1_1_0_1 L0_N1309 L1_N297 1.6882235068e+05
R_Conv_1_11_5_1_1_1_0 L0_N1310 L1_N297 1.0472083211e+05
R_Conv_1_11_5_1_1_1_1 L0_N1311 L1_N297 2.1167619859e+05
R_Conv_1_11_5_1_1_2_0 L0_N1312 L1_N297 1.3518319025e+05
R_Conv_1_11_5_1_1_2_1 L0_N1313 L1_N297 1.4280846670e+05
R_Conv_1_11_5_1_2_0_0 L0_N1364 L1_N297 1.1620759255e+05
R_Conv_1_11_5_1_2_0_1 L0_N1365 L1_N297 1.6895116802e+05
R_Conv_1_11_5_1_2_1_0 L0_N1366 L1_N297 1.2455043512e+06
R_Conv_1_11_5_1_2_1_1 L0_N1367 L1_N297 1.1694022847e+05
R_Conv_1_11_5_1_2_2_0 L0_N1368 L1_N297 1.5663616684e+06
R_Conv_1_11_5_1_2_2_1 L0_N1369 L1_N297 2.1466641264e+05
*
R_Conv_1_11_6_0_0_0_0 L0_N1256 L1_N298 3.0927915375e+05
R_Conv_1_11_6_0_0_0_1 L0_N1257 L1_N298 3.6154472179e+05
R_Conv_1_11_6_0_0_1_0 L0_N1258 L1_N298 1.2307612303e+05
R_Conv_1_11_6_0_0_1_1 L0_N1259 L1_N298 1.3361401953e+06
R_Conv_1_11_6_0_0_2_0 L0_N1260 L1_N298 1.1771240850e+06
R_Conv_1_11_6_0_0_2_1 L0_N1261 L1_N298 1.1947062568e+05
R_Conv_1_11_6_0_1_0_0 L0_N1312 L1_N298 3.4555602430e+05
R_Conv_1_11_6_0_1_0_1 L0_N1313 L1_N298 1.2140655673e+05
R_Conv_1_11_6_0_1_1_0 L0_N1314 L1_N298 2.0024008865e+05
R_Conv_1_11_6_0_1_1_1 L0_N1315 L1_N298 1.3019124074e+05
R_Conv_1_11_6_0_1_2_0 L0_N1316 L1_N298 1.1085089352e+05
R_Conv_1_11_6_0_1_2_1 L0_N1317 L1_N298 2.5251460583e+05
R_Conv_1_11_6_0_2_0_0 L0_N1368 L1_N298 1.1040315248e+05
R_Conv_1_11_6_0_2_0_1 L0_N1369 L1_N298 1.2105931856e+05
R_Conv_1_11_6_0_2_1_0 L0_N1370 L1_N298 1.0186236681e+05
R_Conv_1_11_6_0_2_1_1 L0_N1371 L1_N298 3.8798345399e+05
R_Conv_1_11_6_0_2_2_0 L0_N1372 L1_N298 4.4022254443e+06
R_Conv_1_11_6_0_2_2_1 L0_N1373 L1_N298 1.5358515901e+05
*
R_Conv_1_11_6_1_0_0_0 L0_N1256 L1_N299 1.2123709737e+05
R_Conv_1_11_6_1_0_0_1 L0_N1257 L1_N299 1.0849154640e+05
R_Conv_1_11_6_1_0_1_0 L0_N1258 L1_N299 2.0480317885e+05
R_Conv_1_11_6_1_0_1_1 L0_N1259 L1_N299 1.6641635952e+05
R_Conv_1_11_6_1_0_2_0 L0_N1260 L1_N299 1.1683261279e+06
R_Conv_1_11_6_1_0_2_1 L0_N1261 L1_N299 1.1602008983e+05
R_Conv_1_11_6_1_1_0_0 L0_N1312 L1_N299 1.2296662853e+05
R_Conv_1_11_6_1_1_0_1 L0_N1313 L1_N299 1.6882235068e+05
R_Conv_1_11_6_1_1_1_0 L0_N1314 L1_N299 1.0472083211e+05
R_Conv_1_11_6_1_1_1_1 L0_N1315 L1_N299 2.1167619859e+05
R_Conv_1_11_6_1_1_2_0 L0_N1316 L1_N299 1.3518319025e+05
R_Conv_1_11_6_1_1_2_1 L0_N1317 L1_N299 1.4280846670e+05
R_Conv_1_11_6_1_2_0_0 L0_N1368 L1_N299 1.1620759255e+05
R_Conv_1_11_6_1_2_0_1 L0_N1369 L1_N299 1.6895116802e+05
R_Conv_1_11_6_1_2_1_0 L0_N1370 L1_N299 1.2455043512e+06
R_Conv_1_11_6_1_2_1_1 L0_N1371 L1_N299 1.1694022847e+05
R_Conv_1_11_6_1_2_2_0 L0_N1372 L1_N299 1.5663616684e+06
R_Conv_1_11_6_1_2_2_1 L0_N1373 L1_N299 2.1466641264e+05
*
R_Conv_1_11_7_0_0_0_0 L0_N1260 L1_N300 3.0927915375e+05
R_Conv_1_11_7_0_0_0_1 L0_N1261 L1_N300 3.6154472179e+05
R_Conv_1_11_7_0_0_1_0 L0_N1262 L1_N300 1.2307612303e+05
R_Conv_1_11_7_0_0_1_1 L0_N1263 L1_N300 1.3361401953e+06
R_Conv_1_11_7_0_0_2_0 L0_N1264 L1_N300 1.1771240850e+06
R_Conv_1_11_7_0_0_2_1 L0_N1265 L1_N300 1.1947062568e+05
R_Conv_1_11_7_0_1_0_0 L0_N1316 L1_N300 3.4555602430e+05
R_Conv_1_11_7_0_1_0_1 L0_N1317 L1_N300 1.2140655673e+05
R_Conv_1_11_7_0_1_1_0 L0_N1318 L1_N300 2.0024008865e+05
R_Conv_1_11_7_0_1_1_1 L0_N1319 L1_N300 1.3019124074e+05
R_Conv_1_11_7_0_1_2_0 L0_N1320 L1_N300 1.1085089352e+05
R_Conv_1_11_7_0_1_2_1 L0_N1321 L1_N300 2.5251460583e+05
R_Conv_1_11_7_0_2_0_0 L0_N1372 L1_N300 1.1040315248e+05
R_Conv_1_11_7_0_2_0_1 L0_N1373 L1_N300 1.2105931856e+05
R_Conv_1_11_7_0_2_1_0 L0_N1374 L1_N300 1.0186236681e+05
R_Conv_1_11_7_0_2_1_1 L0_N1375 L1_N300 3.8798345399e+05
R_Conv_1_11_7_0_2_2_0 L0_N1376 L1_N300 4.4022254443e+06
R_Conv_1_11_7_0_2_2_1 L0_N1377 L1_N300 1.5358515901e+05
*
R_Conv_1_11_7_1_0_0_0 L0_N1260 L1_N301 1.2123709737e+05
R_Conv_1_11_7_1_0_0_1 L0_N1261 L1_N301 1.0849154640e+05
R_Conv_1_11_7_1_0_1_0 L0_N1262 L1_N301 2.0480317885e+05
R_Conv_1_11_7_1_0_1_1 L0_N1263 L1_N301 1.6641635952e+05
R_Conv_1_11_7_1_0_2_0 L0_N1264 L1_N301 1.1683261279e+06
R_Conv_1_11_7_1_0_2_1 L0_N1265 L1_N301 1.1602008983e+05
R_Conv_1_11_7_1_1_0_0 L0_N1316 L1_N301 1.2296662853e+05
R_Conv_1_11_7_1_1_0_1 L0_N1317 L1_N301 1.6882235068e+05
R_Conv_1_11_7_1_1_1_0 L0_N1318 L1_N301 1.0472083211e+05
R_Conv_1_11_7_1_1_1_1 L0_N1319 L1_N301 2.1167619859e+05
R_Conv_1_11_7_1_1_2_0 L0_N1320 L1_N301 1.3518319025e+05
R_Conv_1_11_7_1_1_2_1 L0_N1321 L1_N301 1.4280846670e+05
R_Conv_1_11_7_1_2_0_0 L0_N1372 L1_N301 1.1620759255e+05
R_Conv_1_11_7_1_2_0_1 L0_N1373 L1_N301 1.6895116802e+05
R_Conv_1_11_7_1_2_1_0 L0_N1374 L1_N301 1.2455043512e+06
R_Conv_1_11_7_1_2_1_1 L0_N1375 L1_N301 1.1694022847e+05
R_Conv_1_11_7_1_2_2_0 L0_N1376 L1_N301 1.5663616684e+06
R_Conv_1_11_7_1_2_2_1 L0_N1377 L1_N301 2.1466641264e+05
*
R_Conv_1_11_8_0_0_0_0 L0_N1264 L1_N302 3.0927915375e+05
R_Conv_1_11_8_0_0_0_1 L0_N1265 L1_N302 3.6154472179e+05
R_Conv_1_11_8_0_0_1_0 L0_N1266 L1_N302 1.2307612303e+05
R_Conv_1_11_8_0_0_1_1 L0_N1267 L1_N302 1.3361401953e+06
R_Conv_1_11_8_0_0_2_0 L0_N1268 L1_N302 1.1771240850e+06
R_Conv_1_11_8_0_0_2_1 L0_N1269 L1_N302 1.1947062568e+05
R_Conv_1_11_8_0_1_0_0 L0_N1320 L1_N302 3.4555602430e+05
R_Conv_1_11_8_0_1_0_1 L0_N1321 L1_N302 1.2140655673e+05
R_Conv_1_11_8_0_1_1_0 L0_N1322 L1_N302 2.0024008865e+05
R_Conv_1_11_8_0_1_1_1 L0_N1323 L1_N302 1.3019124074e+05
R_Conv_1_11_8_0_1_2_0 L0_N1324 L1_N302 1.1085089352e+05
R_Conv_1_11_8_0_1_2_1 L0_N1325 L1_N302 2.5251460583e+05
R_Conv_1_11_8_0_2_0_0 L0_N1376 L1_N302 1.1040315248e+05
R_Conv_1_11_8_0_2_0_1 L0_N1377 L1_N302 1.2105931856e+05
R_Conv_1_11_8_0_2_1_0 L0_N1378 L1_N302 1.0186236681e+05
R_Conv_1_11_8_0_2_1_1 L0_N1379 L1_N302 3.8798345399e+05
R_Conv_1_11_8_0_2_2_0 L0_N1380 L1_N302 4.4022254443e+06
R_Conv_1_11_8_0_2_2_1 L0_N1381 L1_N302 1.5358515901e+05
*
R_Conv_1_11_8_1_0_0_0 L0_N1264 L1_N303 1.2123709737e+05
R_Conv_1_11_8_1_0_0_1 L0_N1265 L1_N303 1.0849154640e+05
R_Conv_1_11_8_1_0_1_0 L0_N1266 L1_N303 2.0480317885e+05
R_Conv_1_11_8_1_0_1_1 L0_N1267 L1_N303 1.6641635952e+05
R_Conv_1_11_8_1_0_2_0 L0_N1268 L1_N303 1.1683261279e+06
R_Conv_1_11_8_1_0_2_1 L0_N1269 L1_N303 1.1602008983e+05
R_Conv_1_11_8_1_1_0_0 L0_N1320 L1_N303 1.2296662853e+05
R_Conv_1_11_8_1_1_0_1 L0_N1321 L1_N303 1.6882235068e+05
R_Conv_1_11_8_1_1_1_0 L0_N1322 L1_N303 1.0472083211e+05
R_Conv_1_11_8_1_1_1_1 L0_N1323 L1_N303 2.1167619859e+05
R_Conv_1_11_8_1_1_2_0 L0_N1324 L1_N303 1.3518319025e+05
R_Conv_1_11_8_1_1_2_1 L0_N1325 L1_N303 1.4280846670e+05
R_Conv_1_11_8_1_2_0_0 L0_N1376 L1_N303 1.1620759255e+05
R_Conv_1_11_8_1_2_0_1 L0_N1377 L1_N303 1.6895116802e+05
R_Conv_1_11_8_1_2_1_0 L0_N1378 L1_N303 1.2455043512e+06
R_Conv_1_11_8_1_2_1_1 L0_N1379 L1_N303 1.1694022847e+05
R_Conv_1_11_8_1_2_2_0 L0_N1380 L1_N303 1.5663616684e+06
R_Conv_1_11_8_1_2_2_1 L0_N1381 L1_N303 2.1466641264e+05
*
R_Conv_1_11_9_0_0_0_0 L0_N1268 L1_N304 3.0927915375e+05
R_Conv_1_11_9_0_0_0_1 L0_N1269 L1_N304 3.6154472179e+05
R_Conv_1_11_9_0_0_1_0 L0_N1270 L1_N304 1.2307612303e+05
R_Conv_1_11_9_0_0_1_1 L0_N1271 L1_N304 1.3361401953e+06
R_Conv_1_11_9_0_0_2_0 L0_N1272 L1_N304 1.1771240850e+06
R_Conv_1_11_9_0_0_2_1 L0_N1273 L1_N304 1.1947062568e+05
R_Conv_1_11_9_0_1_0_0 L0_N1324 L1_N304 3.4555602430e+05
R_Conv_1_11_9_0_1_0_1 L0_N1325 L1_N304 1.2140655673e+05
R_Conv_1_11_9_0_1_1_0 L0_N1326 L1_N304 2.0024008865e+05
R_Conv_1_11_9_0_1_1_1 L0_N1327 L1_N304 1.3019124074e+05
R_Conv_1_11_9_0_1_2_0 L0_N1328 L1_N304 1.1085089352e+05
R_Conv_1_11_9_0_1_2_1 L0_N1329 L1_N304 2.5251460583e+05
R_Conv_1_11_9_0_2_0_0 L0_N1380 L1_N304 1.1040315248e+05
R_Conv_1_11_9_0_2_0_1 L0_N1381 L1_N304 1.2105931856e+05
R_Conv_1_11_9_0_2_1_0 L0_N1382 L1_N304 1.0186236681e+05
R_Conv_1_11_9_0_2_1_1 L0_N1383 L1_N304 3.8798345399e+05
R_Conv_1_11_9_0_2_2_0 L0_N1384 L1_N304 4.4022254443e+06
R_Conv_1_11_9_0_2_2_1 L0_N1385 L1_N304 1.5358515901e+05
*
R_Conv_1_11_9_1_0_0_0 L0_N1268 L1_N305 1.2123709737e+05
R_Conv_1_11_9_1_0_0_1 L0_N1269 L1_N305 1.0849154640e+05
R_Conv_1_11_9_1_0_1_0 L0_N1270 L1_N305 2.0480317885e+05
R_Conv_1_11_9_1_0_1_1 L0_N1271 L1_N305 1.6641635952e+05
R_Conv_1_11_9_1_0_2_0 L0_N1272 L1_N305 1.1683261279e+06
R_Conv_1_11_9_1_0_2_1 L0_N1273 L1_N305 1.1602008983e+05
R_Conv_1_11_9_1_1_0_0 L0_N1324 L1_N305 1.2296662853e+05
R_Conv_1_11_9_1_1_0_1 L0_N1325 L1_N305 1.6882235068e+05
R_Conv_1_11_9_1_1_1_0 L0_N1326 L1_N305 1.0472083211e+05
R_Conv_1_11_9_1_1_1_1 L0_N1327 L1_N305 2.1167619859e+05
R_Conv_1_11_9_1_1_2_0 L0_N1328 L1_N305 1.3518319025e+05
R_Conv_1_11_9_1_1_2_1 L0_N1329 L1_N305 1.4280846670e+05
R_Conv_1_11_9_1_2_0_0 L0_N1380 L1_N305 1.1620759255e+05
R_Conv_1_11_9_1_2_0_1 L0_N1381 L1_N305 1.6895116802e+05
R_Conv_1_11_9_1_2_1_0 L0_N1382 L1_N305 1.2455043512e+06
R_Conv_1_11_9_1_2_1_1 L0_N1383 L1_N305 1.1694022847e+05
R_Conv_1_11_9_1_2_2_0 L0_N1384 L1_N305 1.5663616684e+06
R_Conv_1_11_9_1_2_2_1 L0_N1385 L1_N305 2.1466641264e+05
*
R_Conv_1_11_10_0_0_0_0 L0_N1272 L1_N306 3.0927915375e+05
R_Conv_1_11_10_0_0_0_1 L0_N1273 L1_N306 3.6154472179e+05
R_Conv_1_11_10_0_0_1_0 L0_N1274 L1_N306 1.2307612303e+05
R_Conv_1_11_10_0_0_1_1 L0_N1275 L1_N306 1.3361401953e+06
R_Conv_1_11_10_0_0_2_0 L0_N1276 L1_N306 1.1771240850e+06
R_Conv_1_11_10_0_0_2_1 L0_N1277 L1_N306 1.1947062568e+05
R_Conv_1_11_10_0_1_0_0 L0_N1328 L1_N306 3.4555602430e+05
R_Conv_1_11_10_0_1_0_1 L0_N1329 L1_N306 1.2140655673e+05
R_Conv_1_11_10_0_1_1_0 L0_N1330 L1_N306 2.0024008865e+05
R_Conv_1_11_10_0_1_1_1 L0_N1331 L1_N306 1.3019124074e+05
R_Conv_1_11_10_0_1_2_0 L0_N1332 L1_N306 1.1085089352e+05
R_Conv_1_11_10_0_1_2_1 L0_N1333 L1_N306 2.5251460583e+05
R_Conv_1_11_10_0_2_0_0 L0_N1384 L1_N306 1.1040315248e+05
R_Conv_1_11_10_0_2_0_1 L0_N1385 L1_N306 1.2105931856e+05
R_Conv_1_11_10_0_2_1_0 L0_N1386 L1_N306 1.0186236681e+05
R_Conv_1_11_10_0_2_1_1 L0_N1387 L1_N306 3.8798345399e+05
R_Conv_1_11_10_0_2_2_0 L0_N1388 L1_N306 4.4022254443e+06
R_Conv_1_11_10_0_2_2_1 L0_N1389 L1_N306 1.5358515901e+05
*
R_Conv_1_11_10_1_0_0_0 L0_N1272 L1_N307 1.2123709737e+05
R_Conv_1_11_10_1_0_0_1 L0_N1273 L1_N307 1.0849154640e+05
R_Conv_1_11_10_1_0_1_0 L0_N1274 L1_N307 2.0480317885e+05
R_Conv_1_11_10_1_0_1_1 L0_N1275 L1_N307 1.6641635952e+05
R_Conv_1_11_10_1_0_2_0 L0_N1276 L1_N307 1.1683261279e+06
R_Conv_1_11_10_1_0_2_1 L0_N1277 L1_N307 1.1602008983e+05
R_Conv_1_11_10_1_1_0_0 L0_N1328 L1_N307 1.2296662853e+05
R_Conv_1_11_10_1_1_0_1 L0_N1329 L1_N307 1.6882235068e+05
R_Conv_1_11_10_1_1_1_0 L0_N1330 L1_N307 1.0472083211e+05
R_Conv_1_11_10_1_1_1_1 L0_N1331 L1_N307 2.1167619859e+05
R_Conv_1_11_10_1_1_2_0 L0_N1332 L1_N307 1.3518319025e+05
R_Conv_1_11_10_1_1_2_1 L0_N1333 L1_N307 1.4280846670e+05
R_Conv_1_11_10_1_2_0_0 L0_N1384 L1_N307 1.1620759255e+05
R_Conv_1_11_10_1_2_0_1 L0_N1385 L1_N307 1.6895116802e+05
R_Conv_1_11_10_1_2_1_0 L0_N1386 L1_N307 1.2455043512e+06
R_Conv_1_11_10_1_2_1_1 L0_N1387 L1_N307 1.1694022847e+05
R_Conv_1_11_10_1_2_2_0 L0_N1388 L1_N307 1.5663616684e+06
R_Conv_1_11_10_1_2_2_1 L0_N1389 L1_N307 2.1466641264e+05
*
R_Conv_1_11_11_0_0_0_0 L0_N1276 L1_N308 3.0927915375e+05
R_Conv_1_11_11_0_0_0_1 L0_N1277 L1_N308 3.6154472179e+05
R_Conv_1_11_11_0_0_1_0 L0_N1278 L1_N308 1.2307612303e+05
R_Conv_1_11_11_0_0_1_1 L0_N1279 L1_N308 1.3361401953e+06
R_Conv_1_11_11_0_0_2_0 L0_N1280 L1_N308 1.1771240850e+06
R_Conv_1_11_11_0_0_2_1 L0_N1281 L1_N308 1.1947062568e+05
R_Conv_1_11_11_0_1_0_0 L0_N1332 L1_N308 3.4555602430e+05
R_Conv_1_11_11_0_1_0_1 L0_N1333 L1_N308 1.2140655673e+05
R_Conv_1_11_11_0_1_1_0 L0_N1334 L1_N308 2.0024008865e+05
R_Conv_1_11_11_0_1_1_1 L0_N1335 L1_N308 1.3019124074e+05
R_Conv_1_11_11_0_1_2_0 L0_N1336 L1_N308 1.1085089352e+05
R_Conv_1_11_11_0_1_2_1 L0_N1337 L1_N308 2.5251460583e+05
R_Conv_1_11_11_0_2_0_0 L0_N1388 L1_N308 1.1040315248e+05
R_Conv_1_11_11_0_2_0_1 L0_N1389 L1_N308 1.2105931856e+05
R_Conv_1_11_11_0_2_1_0 L0_N1390 L1_N308 1.0186236681e+05
R_Conv_1_11_11_0_2_1_1 L0_N1391 L1_N308 3.8798345399e+05
R_Conv_1_11_11_0_2_2_0 L0_N1392 L1_N308 4.4022254443e+06
R_Conv_1_11_11_0_2_2_1 L0_N1393 L1_N308 1.5358515901e+05
*
R_Conv_1_11_11_1_0_0_0 L0_N1276 L1_N309 1.2123709737e+05
R_Conv_1_11_11_1_0_0_1 L0_N1277 L1_N309 1.0849154640e+05
R_Conv_1_11_11_1_0_1_0 L0_N1278 L1_N309 2.0480317885e+05
R_Conv_1_11_11_1_0_1_1 L0_N1279 L1_N309 1.6641635952e+05
R_Conv_1_11_11_1_0_2_0 L0_N1280 L1_N309 1.1683261279e+06
R_Conv_1_11_11_1_0_2_1 L0_N1281 L1_N309 1.1602008983e+05
R_Conv_1_11_11_1_1_0_0 L0_N1332 L1_N309 1.2296662853e+05
R_Conv_1_11_11_1_1_0_1 L0_N1333 L1_N309 1.6882235068e+05
R_Conv_1_11_11_1_1_1_0 L0_N1334 L1_N309 1.0472083211e+05
R_Conv_1_11_11_1_1_1_1 L0_N1335 L1_N309 2.1167619859e+05
R_Conv_1_11_11_1_1_2_0 L0_N1336 L1_N309 1.3518319025e+05
R_Conv_1_11_11_1_1_2_1 L0_N1337 L1_N309 1.4280846670e+05
R_Conv_1_11_11_1_2_0_0 L0_N1388 L1_N309 1.1620759255e+05
R_Conv_1_11_11_1_2_0_1 L0_N1389 L1_N309 1.6895116802e+05
R_Conv_1_11_11_1_2_1_0 L0_N1390 L1_N309 1.2455043512e+06
R_Conv_1_11_11_1_2_1_1 L0_N1391 L1_N309 1.1694022847e+05
R_Conv_1_11_11_1_2_2_0 L0_N1392 L1_N309 1.5663616684e+06
R_Conv_1_11_11_1_2_2_1 L0_N1393 L1_N309 2.1466641264e+05
*
R_Conv_1_11_12_0_0_0_0 L0_N1280 L1_N310 3.0927915375e+05
R_Conv_1_11_12_0_0_0_1 L0_N1281 L1_N310 3.6154472179e+05
R_Conv_1_11_12_0_0_1_0 L0_N1282 L1_N310 1.2307612303e+05
R_Conv_1_11_12_0_0_1_1 L0_N1283 L1_N310 1.3361401953e+06
R_Conv_1_11_12_0_0_2_0 L0_N1284 L1_N310 1.1771240850e+06
R_Conv_1_11_12_0_0_2_1 L0_N1285 L1_N310 1.1947062568e+05
R_Conv_1_11_12_0_1_0_0 L0_N1336 L1_N310 3.4555602430e+05
R_Conv_1_11_12_0_1_0_1 L0_N1337 L1_N310 1.2140655673e+05
R_Conv_1_11_12_0_1_1_0 L0_N1338 L1_N310 2.0024008865e+05
R_Conv_1_11_12_0_1_1_1 L0_N1339 L1_N310 1.3019124074e+05
R_Conv_1_11_12_0_1_2_0 L0_N1340 L1_N310 1.1085089352e+05
R_Conv_1_11_12_0_1_2_1 L0_N1341 L1_N310 2.5251460583e+05
R_Conv_1_11_12_0_2_0_0 L0_N1392 L1_N310 1.1040315248e+05
R_Conv_1_11_12_0_2_0_1 L0_N1393 L1_N310 1.2105931856e+05
R_Conv_1_11_12_0_2_1_0 L0_N1394 L1_N310 1.0186236681e+05
R_Conv_1_11_12_0_2_1_1 L0_N1395 L1_N310 3.8798345399e+05
R_Conv_1_11_12_0_2_2_0 L0_N1396 L1_N310 4.4022254443e+06
R_Conv_1_11_12_0_2_2_1 L0_N1397 L1_N310 1.5358515901e+05
*
R_Conv_1_11_12_1_0_0_0 L0_N1280 L1_N311 1.2123709737e+05
R_Conv_1_11_12_1_0_0_1 L0_N1281 L1_N311 1.0849154640e+05
R_Conv_1_11_12_1_0_1_0 L0_N1282 L1_N311 2.0480317885e+05
R_Conv_1_11_12_1_0_1_1 L0_N1283 L1_N311 1.6641635952e+05
R_Conv_1_11_12_1_0_2_0 L0_N1284 L1_N311 1.1683261279e+06
R_Conv_1_11_12_1_0_2_1 L0_N1285 L1_N311 1.1602008983e+05
R_Conv_1_11_12_1_1_0_0 L0_N1336 L1_N311 1.2296662853e+05
R_Conv_1_11_12_1_1_0_1 L0_N1337 L1_N311 1.6882235068e+05
R_Conv_1_11_12_1_1_1_0 L0_N1338 L1_N311 1.0472083211e+05
R_Conv_1_11_12_1_1_1_1 L0_N1339 L1_N311 2.1167619859e+05
R_Conv_1_11_12_1_1_2_0 L0_N1340 L1_N311 1.3518319025e+05
R_Conv_1_11_12_1_1_2_1 L0_N1341 L1_N311 1.4280846670e+05
R_Conv_1_11_12_1_2_0_0 L0_N1392 L1_N311 1.1620759255e+05
R_Conv_1_11_12_1_2_0_1 L0_N1393 L1_N311 1.6895116802e+05
R_Conv_1_11_12_1_2_1_0 L0_N1394 L1_N311 1.2455043512e+06
R_Conv_1_11_12_1_2_1_1 L0_N1395 L1_N311 1.1694022847e+05
R_Conv_1_11_12_1_2_2_0 L0_N1396 L1_N311 1.5663616684e+06
R_Conv_1_11_12_1_2_2_1 L0_N1397 L1_N311 2.1466641264e+05
*
R_Conv_1_12_0_0_0_0_0 L0_N1344 L1_N312 3.0927915375e+05
R_Conv_1_12_0_0_0_0_1 L0_N1345 L1_N312 3.6154472179e+05
R_Conv_1_12_0_0_0_1_0 L0_N1346 L1_N312 1.2307612303e+05
R_Conv_1_12_0_0_0_1_1 L0_N1347 L1_N312 1.3361401953e+06
R_Conv_1_12_0_0_0_2_0 L0_N1348 L1_N312 1.1771240850e+06
R_Conv_1_12_0_0_0_2_1 L0_N1349 L1_N312 1.1947062568e+05
R_Conv_1_12_0_0_1_0_0 L0_N1400 L1_N312 3.4555602430e+05
R_Conv_1_12_0_0_1_0_1 L0_N1401 L1_N312 1.2140655673e+05
R_Conv_1_12_0_0_1_1_0 L0_N1402 L1_N312 2.0024008865e+05
R_Conv_1_12_0_0_1_1_1 L0_N1403 L1_N312 1.3019124074e+05
R_Conv_1_12_0_0_1_2_0 L0_N1404 L1_N312 1.1085089352e+05
R_Conv_1_12_0_0_1_2_1 L0_N1405 L1_N312 2.5251460583e+05
R_Conv_1_12_0_0_2_0_0 L0_N1456 L1_N312 1.1040315248e+05
R_Conv_1_12_0_0_2_0_1 L0_N1457 L1_N312 1.2105931856e+05
R_Conv_1_12_0_0_2_1_0 L0_N1458 L1_N312 1.0186236681e+05
R_Conv_1_12_0_0_2_1_1 L0_N1459 L1_N312 3.8798345399e+05
R_Conv_1_12_0_0_2_2_0 L0_N1460 L1_N312 4.4022254443e+06
R_Conv_1_12_0_0_2_2_1 L0_N1461 L1_N312 1.5358515901e+05
*
R_Conv_1_12_0_1_0_0_0 L0_N1344 L1_N313 1.2123709737e+05
R_Conv_1_12_0_1_0_0_1 L0_N1345 L1_N313 1.0849154640e+05
R_Conv_1_12_0_1_0_1_0 L0_N1346 L1_N313 2.0480317885e+05
R_Conv_1_12_0_1_0_1_1 L0_N1347 L1_N313 1.6641635952e+05
R_Conv_1_12_0_1_0_2_0 L0_N1348 L1_N313 1.1683261279e+06
R_Conv_1_12_0_1_0_2_1 L0_N1349 L1_N313 1.1602008983e+05
R_Conv_1_12_0_1_1_0_0 L0_N1400 L1_N313 1.2296662853e+05
R_Conv_1_12_0_1_1_0_1 L0_N1401 L1_N313 1.6882235068e+05
R_Conv_1_12_0_1_1_1_0 L0_N1402 L1_N313 1.0472083211e+05
R_Conv_1_12_0_1_1_1_1 L0_N1403 L1_N313 2.1167619859e+05
R_Conv_1_12_0_1_1_2_0 L0_N1404 L1_N313 1.3518319025e+05
R_Conv_1_12_0_1_1_2_1 L0_N1405 L1_N313 1.4280846670e+05
R_Conv_1_12_0_1_2_0_0 L0_N1456 L1_N313 1.1620759255e+05
R_Conv_1_12_0_1_2_0_1 L0_N1457 L1_N313 1.6895116802e+05
R_Conv_1_12_0_1_2_1_0 L0_N1458 L1_N313 1.2455043512e+06
R_Conv_1_12_0_1_2_1_1 L0_N1459 L1_N313 1.1694022847e+05
R_Conv_1_12_0_1_2_2_0 L0_N1460 L1_N313 1.5663616684e+06
R_Conv_1_12_0_1_2_2_1 L0_N1461 L1_N313 2.1466641264e+05
*
R_Conv_1_12_1_0_0_0_0 L0_N1348 L1_N314 3.0927915375e+05
R_Conv_1_12_1_0_0_0_1 L0_N1349 L1_N314 3.6154472179e+05
R_Conv_1_12_1_0_0_1_0 L0_N1350 L1_N314 1.2307612303e+05
R_Conv_1_12_1_0_0_1_1 L0_N1351 L1_N314 1.3361401953e+06
R_Conv_1_12_1_0_0_2_0 L0_N1352 L1_N314 1.1771240850e+06
R_Conv_1_12_1_0_0_2_1 L0_N1353 L1_N314 1.1947062568e+05
R_Conv_1_12_1_0_1_0_0 L0_N1404 L1_N314 3.4555602430e+05
R_Conv_1_12_1_0_1_0_1 L0_N1405 L1_N314 1.2140655673e+05
R_Conv_1_12_1_0_1_1_0 L0_N1406 L1_N314 2.0024008865e+05
R_Conv_1_12_1_0_1_1_1 L0_N1407 L1_N314 1.3019124074e+05
R_Conv_1_12_1_0_1_2_0 L0_N1408 L1_N314 1.1085089352e+05
R_Conv_1_12_1_0_1_2_1 L0_N1409 L1_N314 2.5251460583e+05
R_Conv_1_12_1_0_2_0_0 L0_N1460 L1_N314 1.1040315248e+05
R_Conv_1_12_1_0_2_0_1 L0_N1461 L1_N314 1.2105931856e+05
R_Conv_1_12_1_0_2_1_0 L0_N1462 L1_N314 1.0186236681e+05
R_Conv_1_12_1_0_2_1_1 L0_N1463 L1_N314 3.8798345399e+05
R_Conv_1_12_1_0_2_2_0 L0_N1464 L1_N314 4.4022254443e+06
R_Conv_1_12_1_0_2_2_1 L0_N1465 L1_N314 1.5358515901e+05
*
R_Conv_1_12_1_1_0_0_0 L0_N1348 L1_N315 1.2123709737e+05
R_Conv_1_12_1_1_0_0_1 L0_N1349 L1_N315 1.0849154640e+05
R_Conv_1_12_1_1_0_1_0 L0_N1350 L1_N315 2.0480317885e+05
R_Conv_1_12_1_1_0_1_1 L0_N1351 L1_N315 1.6641635952e+05
R_Conv_1_12_1_1_0_2_0 L0_N1352 L1_N315 1.1683261279e+06
R_Conv_1_12_1_1_0_2_1 L0_N1353 L1_N315 1.1602008983e+05
R_Conv_1_12_1_1_1_0_0 L0_N1404 L1_N315 1.2296662853e+05
R_Conv_1_12_1_1_1_0_1 L0_N1405 L1_N315 1.6882235068e+05
R_Conv_1_12_1_1_1_1_0 L0_N1406 L1_N315 1.0472083211e+05
R_Conv_1_12_1_1_1_1_1 L0_N1407 L1_N315 2.1167619859e+05
R_Conv_1_12_1_1_1_2_0 L0_N1408 L1_N315 1.3518319025e+05
R_Conv_1_12_1_1_1_2_1 L0_N1409 L1_N315 1.4280846670e+05
R_Conv_1_12_1_1_2_0_0 L0_N1460 L1_N315 1.1620759255e+05
R_Conv_1_12_1_1_2_0_1 L0_N1461 L1_N315 1.6895116802e+05
R_Conv_1_12_1_1_2_1_0 L0_N1462 L1_N315 1.2455043512e+06
R_Conv_1_12_1_1_2_1_1 L0_N1463 L1_N315 1.1694022847e+05
R_Conv_1_12_1_1_2_2_0 L0_N1464 L1_N315 1.5663616684e+06
R_Conv_1_12_1_1_2_2_1 L0_N1465 L1_N315 2.1466641264e+05
*
R_Conv_1_12_2_0_0_0_0 L0_N1352 L1_N316 3.0927915375e+05
R_Conv_1_12_2_0_0_0_1 L0_N1353 L1_N316 3.6154472179e+05
R_Conv_1_12_2_0_0_1_0 L0_N1354 L1_N316 1.2307612303e+05
R_Conv_1_12_2_0_0_1_1 L0_N1355 L1_N316 1.3361401953e+06
R_Conv_1_12_2_0_0_2_0 L0_N1356 L1_N316 1.1771240850e+06
R_Conv_1_12_2_0_0_2_1 L0_N1357 L1_N316 1.1947062568e+05
R_Conv_1_12_2_0_1_0_0 L0_N1408 L1_N316 3.4555602430e+05
R_Conv_1_12_2_0_1_0_1 L0_N1409 L1_N316 1.2140655673e+05
R_Conv_1_12_2_0_1_1_0 L0_N1410 L1_N316 2.0024008865e+05
R_Conv_1_12_2_0_1_1_1 L0_N1411 L1_N316 1.3019124074e+05
R_Conv_1_12_2_0_1_2_0 L0_N1412 L1_N316 1.1085089352e+05
R_Conv_1_12_2_0_1_2_1 L0_N1413 L1_N316 2.5251460583e+05
R_Conv_1_12_2_0_2_0_0 L0_N1464 L1_N316 1.1040315248e+05
R_Conv_1_12_2_0_2_0_1 L0_N1465 L1_N316 1.2105931856e+05
R_Conv_1_12_2_0_2_1_0 L0_N1466 L1_N316 1.0186236681e+05
R_Conv_1_12_2_0_2_1_1 L0_N1467 L1_N316 3.8798345399e+05
R_Conv_1_12_2_0_2_2_0 L0_N1468 L1_N316 4.4022254443e+06
R_Conv_1_12_2_0_2_2_1 L0_N1469 L1_N316 1.5358515901e+05
*
R_Conv_1_12_2_1_0_0_0 L0_N1352 L1_N317 1.2123709737e+05
R_Conv_1_12_2_1_0_0_1 L0_N1353 L1_N317 1.0849154640e+05
R_Conv_1_12_2_1_0_1_0 L0_N1354 L1_N317 2.0480317885e+05
R_Conv_1_12_2_1_0_1_1 L0_N1355 L1_N317 1.6641635952e+05
R_Conv_1_12_2_1_0_2_0 L0_N1356 L1_N317 1.1683261279e+06
R_Conv_1_12_2_1_0_2_1 L0_N1357 L1_N317 1.1602008983e+05
R_Conv_1_12_2_1_1_0_0 L0_N1408 L1_N317 1.2296662853e+05
R_Conv_1_12_2_1_1_0_1 L0_N1409 L1_N317 1.6882235068e+05
R_Conv_1_12_2_1_1_1_0 L0_N1410 L1_N317 1.0472083211e+05
R_Conv_1_12_2_1_1_1_1 L0_N1411 L1_N317 2.1167619859e+05
R_Conv_1_12_2_1_1_2_0 L0_N1412 L1_N317 1.3518319025e+05
R_Conv_1_12_2_1_1_2_1 L0_N1413 L1_N317 1.4280846670e+05
R_Conv_1_12_2_1_2_0_0 L0_N1464 L1_N317 1.1620759255e+05
R_Conv_1_12_2_1_2_0_1 L0_N1465 L1_N317 1.6895116802e+05
R_Conv_1_12_2_1_2_1_0 L0_N1466 L1_N317 1.2455043512e+06
R_Conv_1_12_2_1_2_1_1 L0_N1467 L1_N317 1.1694022847e+05
R_Conv_1_12_2_1_2_2_0 L0_N1468 L1_N317 1.5663616684e+06
R_Conv_1_12_2_1_2_2_1 L0_N1469 L1_N317 2.1466641264e+05
*
R_Conv_1_12_3_0_0_0_0 L0_N1356 L1_N318 3.0927915375e+05
R_Conv_1_12_3_0_0_0_1 L0_N1357 L1_N318 3.6154472179e+05
R_Conv_1_12_3_0_0_1_0 L0_N1358 L1_N318 1.2307612303e+05
R_Conv_1_12_3_0_0_1_1 L0_N1359 L1_N318 1.3361401953e+06
R_Conv_1_12_3_0_0_2_0 L0_N1360 L1_N318 1.1771240850e+06
R_Conv_1_12_3_0_0_2_1 L0_N1361 L1_N318 1.1947062568e+05
R_Conv_1_12_3_0_1_0_0 L0_N1412 L1_N318 3.4555602430e+05
R_Conv_1_12_3_0_1_0_1 L0_N1413 L1_N318 1.2140655673e+05
R_Conv_1_12_3_0_1_1_0 L0_N1414 L1_N318 2.0024008865e+05
R_Conv_1_12_3_0_1_1_1 L0_N1415 L1_N318 1.3019124074e+05
R_Conv_1_12_3_0_1_2_0 L0_N1416 L1_N318 1.1085089352e+05
R_Conv_1_12_3_0_1_2_1 L0_N1417 L1_N318 2.5251460583e+05
R_Conv_1_12_3_0_2_0_0 L0_N1468 L1_N318 1.1040315248e+05
R_Conv_1_12_3_0_2_0_1 L0_N1469 L1_N318 1.2105931856e+05
R_Conv_1_12_3_0_2_1_0 L0_N1470 L1_N318 1.0186236681e+05
R_Conv_1_12_3_0_2_1_1 L0_N1471 L1_N318 3.8798345399e+05
R_Conv_1_12_3_0_2_2_0 L0_N1472 L1_N318 4.4022254443e+06
R_Conv_1_12_3_0_2_2_1 L0_N1473 L1_N318 1.5358515901e+05
*
R_Conv_1_12_3_1_0_0_0 L0_N1356 L1_N319 1.2123709737e+05
R_Conv_1_12_3_1_0_0_1 L0_N1357 L1_N319 1.0849154640e+05
R_Conv_1_12_3_1_0_1_0 L0_N1358 L1_N319 2.0480317885e+05
R_Conv_1_12_3_1_0_1_1 L0_N1359 L1_N319 1.6641635952e+05
R_Conv_1_12_3_1_0_2_0 L0_N1360 L1_N319 1.1683261279e+06
R_Conv_1_12_3_1_0_2_1 L0_N1361 L1_N319 1.1602008983e+05
R_Conv_1_12_3_1_1_0_0 L0_N1412 L1_N319 1.2296662853e+05
R_Conv_1_12_3_1_1_0_1 L0_N1413 L1_N319 1.6882235068e+05
R_Conv_1_12_3_1_1_1_0 L0_N1414 L1_N319 1.0472083211e+05
R_Conv_1_12_3_1_1_1_1 L0_N1415 L1_N319 2.1167619859e+05
R_Conv_1_12_3_1_1_2_0 L0_N1416 L1_N319 1.3518319025e+05
R_Conv_1_12_3_1_1_2_1 L0_N1417 L1_N319 1.4280846670e+05
R_Conv_1_12_3_1_2_0_0 L0_N1468 L1_N319 1.1620759255e+05
R_Conv_1_12_3_1_2_0_1 L0_N1469 L1_N319 1.6895116802e+05
R_Conv_1_12_3_1_2_1_0 L0_N1470 L1_N319 1.2455043512e+06
R_Conv_1_12_3_1_2_1_1 L0_N1471 L1_N319 1.1694022847e+05
R_Conv_1_12_3_1_2_2_0 L0_N1472 L1_N319 1.5663616684e+06
R_Conv_1_12_3_1_2_2_1 L0_N1473 L1_N319 2.1466641264e+05
*
R_Conv_1_12_4_0_0_0_0 L0_N1360 L1_N320 3.0927915375e+05
R_Conv_1_12_4_0_0_0_1 L0_N1361 L1_N320 3.6154472179e+05
R_Conv_1_12_4_0_0_1_0 L0_N1362 L1_N320 1.2307612303e+05
R_Conv_1_12_4_0_0_1_1 L0_N1363 L1_N320 1.3361401953e+06
R_Conv_1_12_4_0_0_2_0 L0_N1364 L1_N320 1.1771240850e+06
R_Conv_1_12_4_0_0_2_1 L0_N1365 L1_N320 1.1947062568e+05
R_Conv_1_12_4_0_1_0_0 L0_N1416 L1_N320 3.4555602430e+05
R_Conv_1_12_4_0_1_0_1 L0_N1417 L1_N320 1.2140655673e+05
R_Conv_1_12_4_0_1_1_0 L0_N1418 L1_N320 2.0024008865e+05
R_Conv_1_12_4_0_1_1_1 L0_N1419 L1_N320 1.3019124074e+05
R_Conv_1_12_4_0_1_2_0 L0_N1420 L1_N320 1.1085089352e+05
R_Conv_1_12_4_0_1_2_1 L0_N1421 L1_N320 2.5251460583e+05
R_Conv_1_12_4_0_2_0_0 L0_N1472 L1_N320 1.1040315248e+05
R_Conv_1_12_4_0_2_0_1 L0_N1473 L1_N320 1.2105931856e+05
R_Conv_1_12_4_0_2_1_0 L0_N1474 L1_N320 1.0186236681e+05
R_Conv_1_12_4_0_2_1_1 L0_N1475 L1_N320 3.8798345399e+05
R_Conv_1_12_4_0_2_2_0 L0_N1476 L1_N320 4.4022254443e+06
R_Conv_1_12_4_0_2_2_1 L0_N1477 L1_N320 1.5358515901e+05
*
R_Conv_1_12_4_1_0_0_0 L0_N1360 L1_N321 1.2123709737e+05
R_Conv_1_12_4_1_0_0_1 L0_N1361 L1_N321 1.0849154640e+05
R_Conv_1_12_4_1_0_1_0 L0_N1362 L1_N321 2.0480317885e+05
R_Conv_1_12_4_1_0_1_1 L0_N1363 L1_N321 1.6641635952e+05
R_Conv_1_12_4_1_0_2_0 L0_N1364 L1_N321 1.1683261279e+06
R_Conv_1_12_4_1_0_2_1 L0_N1365 L1_N321 1.1602008983e+05
R_Conv_1_12_4_1_1_0_0 L0_N1416 L1_N321 1.2296662853e+05
R_Conv_1_12_4_1_1_0_1 L0_N1417 L1_N321 1.6882235068e+05
R_Conv_1_12_4_1_1_1_0 L0_N1418 L1_N321 1.0472083211e+05
R_Conv_1_12_4_1_1_1_1 L0_N1419 L1_N321 2.1167619859e+05
R_Conv_1_12_4_1_1_2_0 L0_N1420 L1_N321 1.3518319025e+05
R_Conv_1_12_4_1_1_2_1 L0_N1421 L1_N321 1.4280846670e+05
R_Conv_1_12_4_1_2_0_0 L0_N1472 L1_N321 1.1620759255e+05
R_Conv_1_12_4_1_2_0_1 L0_N1473 L1_N321 1.6895116802e+05
R_Conv_1_12_4_1_2_1_0 L0_N1474 L1_N321 1.2455043512e+06
R_Conv_1_12_4_1_2_1_1 L0_N1475 L1_N321 1.1694022847e+05
R_Conv_1_12_4_1_2_2_0 L0_N1476 L1_N321 1.5663616684e+06
R_Conv_1_12_4_1_2_2_1 L0_N1477 L1_N321 2.1466641264e+05
*
R_Conv_1_12_5_0_0_0_0 L0_N1364 L1_N322 3.0927915375e+05
R_Conv_1_12_5_0_0_0_1 L0_N1365 L1_N322 3.6154472179e+05
R_Conv_1_12_5_0_0_1_0 L0_N1366 L1_N322 1.2307612303e+05
R_Conv_1_12_5_0_0_1_1 L0_N1367 L1_N322 1.3361401953e+06
R_Conv_1_12_5_0_0_2_0 L0_N1368 L1_N322 1.1771240850e+06
R_Conv_1_12_5_0_0_2_1 L0_N1369 L1_N322 1.1947062568e+05
R_Conv_1_12_5_0_1_0_0 L0_N1420 L1_N322 3.4555602430e+05
R_Conv_1_12_5_0_1_0_1 L0_N1421 L1_N322 1.2140655673e+05
R_Conv_1_12_5_0_1_1_0 L0_N1422 L1_N322 2.0024008865e+05
R_Conv_1_12_5_0_1_1_1 L0_N1423 L1_N322 1.3019124074e+05
R_Conv_1_12_5_0_1_2_0 L0_N1424 L1_N322 1.1085089352e+05
R_Conv_1_12_5_0_1_2_1 L0_N1425 L1_N322 2.5251460583e+05
R_Conv_1_12_5_0_2_0_0 L0_N1476 L1_N322 1.1040315248e+05
R_Conv_1_12_5_0_2_0_1 L0_N1477 L1_N322 1.2105931856e+05
R_Conv_1_12_5_0_2_1_0 L0_N1478 L1_N322 1.0186236681e+05
R_Conv_1_12_5_0_2_1_1 L0_N1479 L1_N322 3.8798345399e+05
R_Conv_1_12_5_0_2_2_0 L0_N1480 L1_N322 4.4022254443e+06
R_Conv_1_12_5_0_2_2_1 L0_N1481 L1_N322 1.5358515901e+05
*
R_Conv_1_12_5_1_0_0_0 L0_N1364 L1_N323 1.2123709737e+05
R_Conv_1_12_5_1_0_0_1 L0_N1365 L1_N323 1.0849154640e+05
R_Conv_1_12_5_1_0_1_0 L0_N1366 L1_N323 2.0480317885e+05
R_Conv_1_12_5_1_0_1_1 L0_N1367 L1_N323 1.6641635952e+05
R_Conv_1_12_5_1_0_2_0 L0_N1368 L1_N323 1.1683261279e+06
R_Conv_1_12_5_1_0_2_1 L0_N1369 L1_N323 1.1602008983e+05
R_Conv_1_12_5_1_1_0_0 L0_N1420 L1_N323 1.2296662853e+05
R_Conv_1_12_5_1_1_0_1 L0_N1421 L1_N323 1.6882235068e+05
R_Conv_1_12_5_1_1_1_0 L0_N1422 L1_N323 1.0472083211e+05
R_Conv_1_12_5_1_1_1_1 L0_N1423 L1_N323 2.1167619859e+05
R_Conv_1_12_5_1_1_2_0 L0_N1424 L1_N323 1.3518319025e+05
R_Conv_1_12_5_1_1_2_1 L0_N1425 L1_N323 1.4280846670e+05
R_Conv_1_12_5_1_2_0_0 L0_N1476 L1_N323 1.1620759255e+05
R_Conv_1_12_5_1_2_0_1 L0_N1477 L1_N323 1.6895116802e+05
R_Conv_1_12_5_1_2_1_0 L0_N1478 L1_N323 1.2455043512e+06
R_Conv_1_12_5_1_2_1_1 L0_N1479 L1_N323 1.1694022847e+05
R_Conv_1_12_5_1_2_2_0 L0_N1480 L1_N323 1.5663616684e+06
R_Conv_1_12_5_1_2_2_1 L0_N1481 L1_N323 2.1466641264e+05
*
R_Conv_1_12_6_0_0_0_0 L0_N1368 L1_N324 3.0927915375e+05
R_Conv_1_12_6_0_0_0_1 L0_N1369 L1_N324 3.6154472179e+05
R_Conv_1_12_6_0_0_1_0 L0_N1370 L1_N324 1.2307612303e+05
R_Conv_1_12_6_0_0_1_1 L0_N1371 L1_N324 1.3361401953e+06
R_Conv_1_12_6_0_0_2_0 L0_N1372 L1_N324 1.1771240850e+06
R_Conv_1_12_6_0_0_2_1 L0_N1373 L1_N324 1.1947062568e+05
R_Conv_1_12_6_0_1_0_0 L0_N1424 L1_N324 3.4555602430e+05
R_Conv_1_12_6_0_1_0_1 L0_N1425 L1_N324 1.2140655673e+05
R_Conv_1_12_6_0_1_1_0 L0_N1426 L1_N324 2.0024008865e+05
R_Conv_1_12_6_0_1_1_1 L0_N1427 L1_N324 1.3019124074e+05
R_Conv_1_12_6_0_1_2_0 L0_N1428 L1_N324 1.1085089352e+05
R_Conv_1_12_6_0_1_2_1 L0_N1429 L1_N324 2.5251460583e+05
R_Conv_1_12_6_0_2_0_0 L0_N1480 L1_N324 1.1040315248e+05
R_Conv_1_12_6_0_2_0_1 L0_N1481 L1_N324 1.2105931856e+05
R_Conv_1_12_6_0_2_1_0 L0_N1482 L1_N324 1.0186236681e+05
R_Conv_1_12_6_0_2_1_1 L0_N1483 L1_N324 3.8798345399e+05
R_Conv_1_12_6_0_2_2_0 L0_N1484 L1_N324 4.4022254443e+06
R_Conv_1_12_6_0_2_2_1 L0_N1485 L1_N324 1.5358515901e+05
*
R_Conv_1_12_6_1_0_0_0 L0_N1368 L1_N325 1.2123709737e+05
R_Conv_1_12_6_1_0_0_1 L0_N1369 L1_N325 1.0849154640e+05
R_Conv_1_12_6_1_0_1_0 L0_N1370 L1_N325 2.0480317885e+05
R_Conv_1_12_6_1_0_1_1 L0_N1371 L1_N325 1.6641635952e+05
R_Conv_1_12_6_1_0_2_0 L0_N1372 L1_N325 1.1683261279e+06
R_Conv_1_12_6_1_0_2_1 L0_N1373 L1_N325 1.1602008983e+05
R_Conv_1_12_6_1_1_0_0 L0_N1424 L1_N325 1.2296662853e+05
R_Conv_1_12_6_1_1_0_1 L0_N1425 L1_N325 1.6882235068e+05
R_Conv_1_12_6_1_1_1_0 L0_N1426 L1_N325 1.0472083211e+05
R_Conv_1_12_6_1_1_1_1 L0_N1427 L1_N325 2.1167619859e+05
R_Conv_1_12_6_1_1_2_0 L0_N1428 L1_N325 1.3518319025e+05
R_Conv_1_12_6_1_1_2_1 L0_N1429 L1_N325 1.4280846670e+05
R_Conv_1_12_6_1_2_0_0 L0_N1480 L1_N325 1.1620759255e+05
R_Conv_1_12_6_1_2_0_1 L0_N1481 L1_N325 1.6895116802e+05
R_Conv_1_12_6_1_2_1_0 L0_N1482 L1_N325 1.2455043512e+06
R_Conv_1_12_6_1_2_1_1 L0_N1483 L1_N325 1.1694022847e+05
R_Conv_1_12_6_1_2_2_0 L0_N1484 L1_N325 1.5663616684e+06
R_Conv_1_12_6_1_2_2_1 L0_N1485 L1_N325 2.1466641264e+05
*
R_Conv_1_12_7_0_0_0_0 L0_N1372 L1_N326 3.0927915375e+05
R_Conv_1_12_7_0_0_0_1 L0_N1373 L1_N326 3.6154472179e+05
R_Conv_1_12_7_0_0_1_0 L0_N1374 L1_N326 1.2307612303e+05
R_Conv_1_12_7_0_0_1_1 L0_N1375 L1_N326 1.3361401953e+06
R_Conv_1_12_7_0_0_2_0 L0_N1376 L1_N326 1.1771240850e+06
R_Conv_1_12_7_0_0_2_1 L0_N1377 L1_N326 1.1947062568e+05
R_Conv_1_12_7_0_1_0_0 L0_N1428 L1_N326 3.4555602430e+05
R_Conv_1_12_7_0_1_0_1 L0_N1429 L1_N326 1.2140655673e+05
R_Conv_1_12_7_0_1_1_0 L0_N1430 L1_N326 2.0024008865e+05
R_Conv_1_12_7_0_1_1_1 L0_N1431 L1_N326 1.3019124074e+05
R_Conv_1_12_7_0_1_2_0 L0_N1432 L1_N326 1.1085089352e+05
R_Conv_1_12_7_0_1_2_1 L0_N1433 L1_N326 2.5251460583e+05
R_Conv_1_12_7_0_2_0_0 L0_N1484 L1_N326 1.1040315248e+05
R_Conv_1_12_7_0_2_0_1 L0_N1485 L1_N326 1.2105931856e+05
R_Conv_1_12_7_0_2_1_0 L0_N1486 L1_N326 1.0186236681e+05
R_Conv_1_12_7_0_2_1_1 L0_N1487 L1_N326 3.8798345399e+05
R_Conv_1_12_7_0_2_2_0 L0_N1488 L1_N326 4.4022254443e+06
R_Conv_1_12_7_0_2_2_1 L0_N1489 L1_N326 1.5358515901e+05
*
R_Conv_1_12_7_1_0_0_0 L0_N1372 L1_N327 1.2123709737e+05
R_Conv_1_12_7_1_0_0_1 L0_N1373 L1_N327 1.0849154640e+05
R_Conv_1_12_7_1_0_1_0 L0_N1374 L1_N327 2.0480317885e+05
R_Conv_1_12_7_1_0_1_1 L0_N1375 L1_N327 1.6641635952e+05
R_Conv_1_12_7_1_0_2_0 L0_N1376 L1_N327 1.1683261279e+06
R_Conv_1_12_7_1_0_2_1 L0_N1377 L1_N327 1.1602008983e+05
R_Conv_1_12_7_1_1_0_0 L0_N1428 L1_N327 1.2296662853e+05
R_Conv_1_12_7_1_1_0_1 L0_N1429 L1_N327 1.6882235068e+05
R_Conv_1_12_7_1_1_1_0 L0_N1430 L1_N327 1.0472083211e+05
R_Conv_1_12_7_1_1_1_1 L0_N1431 L1_N327 2.1167619859e+05
R_Conv_1_12_7_1_1_2_0 L0_N1432 L1_N327 1.3518319025e+05
R_Conv_1_12_7_1_1_2_1 L0_N1433 L1_N327 1.4280846670e+05
R_Conv_1_12_7_1_2_0_0 L0_N1484 L1_N327 1.1620759255e+05
R_Conv_1_12_7_1_2_0_1 L0_N1485 L1_N327 1.6895116802e+05
R_Conv_1_12_7_1_2_1_0 L0_N1486 L1_N327 1.2455043512e+06
R_Conv_1_12_7_1_2_1_1 L0_N1487 L1_N327 1.1694022847e+05
R_Conv_1_12_7_1_2_2_0 L0_N1488 L1_N327 1.5663616684e+06
R_Conv_1_12_7_1_2_2_1 L0_N1489 L1_N327 2.1466641264e+05
*
R_Conv_1_12_8_0_0_0_0 L0_N1376 L1_N328 3.0927915375e+05
R_Conv_1_12_8_0_0_0_1 L0_N1377 L1_N328 3.6154472179e+05
R_Conv_1_12_8_0_0_1_0 L0_N1378 L1_N328 1.2307612303e+05
R_Conv_1_12_8_0_0_1_1 L0_N1379 L1_N328 1.3361401953e+06
R_Conv_1_12_8_0_0_2_0 L0_N1380 L1_N328 1.1771240850e+06
R_Conv_1_12_8_0_0_2_1 L0_N1381 L1_N328 1.1947062568e+05
R_Conv_1_12_8_0_1_0_0 L0_N1432 L1_N328 3.4555602430e+05
R_Conv_1_12_8_0_1_0_1 L0_N1433 L1_N328 1.2140655673e+05
R_Conv_1_12_8_0_1_1_0 L0_N1434 L1_N328 2.0024008865e+05
R_Conv_1_12_8_0_1_1_1 L0_N1435 L1_N328 1.3019124074e+05
R_Conv_1_12_8_0_1_2_0 L0_N1436 L1_N328 1.1085089352e+05
R_Conv_1_12_8_0_1_2_1 L0_N1437 L1_N328 2.5251460583e+05
R_Conv_1_12_8_0_2_0_0 L0_N1488 L1_N328 1.1040315248e+05
R_Conv_1_12_8_0_2_0_1 L0_N1489 L1_N328 1.2105931856e+05
R_Conv_1_12_8_0_2_1_0 L0_N1490 L1_N328 1.0186236681e+05
R_Conv_1_12_8_0_2_1_1 L0_N1491 L1_N328 3.8798345399e+05
R_Conv_1_12_8_0_2_2_0 L0_N1492 L1_N328 4.4022254443e+06
R_Conv_1_12_8_0_2_2_1 L0_N1493 L1_N328 1.5358515901e+05
*
R_Conv_1_12_8_1_0_0_0 L0_N1376 L1_N329 1.2123709737e+05
R_Conv_1_12_8_1_0_0_1 L0_N1377 L1_N329 1.0849154640e+05
R_Conv_1_12_8_1_0_1_0 L0_N1378 L1_N329 2.0480317885e+05
R_Conv_1_12_8_1_0_1_1 L0_N1379 L1_N329 1.6641635952e+05
R_Conv_1_12_8_1_0_2_0 L0_N1380 L1_N329 1.1683261279e+06
R_Conv_1_12_8_1_0_2_1 L0_N1381 L1_N329 1.1602008983e+05
R_Conv_1_12_8_1_1_0_0 L0_N1432 L1_N329 1.2296662853e+05
R_Conv_1_12_8_1_1_0_1 L0_N1433 L1_N329 1.6882235068e+05
R_Conv_1_12_8_1_1_1_0 L0_N1434 L1_N329 1.0472083211e+05
R_Conv_1_12_8_1_1_1_1 L0_N1435 L1_N329 2.1167619859e+05
R_Conv_1_12_8_1_1_2_0 L0_N1436 L1_N329 1.3518319025e+05
R_Conv_1_12_8_1_1_2_1 L0_N1437 L1_N329 1.4280846670e+05
R_Conv_1_12_8_1_2_0_0 L0_N1488 L1_N329 1.1620759255e+05
R_Conv_1_12_8_1_2_0_1 L0_N1489 L1_N329 1.6895116802e+05
R_Conv_1_12_8_1_2_1_0 L0_N1490 L1_N329 1.2455043512e+06
R_Conv_1_12_8_1_2_1_1 L0_N1491 L1_N329 1.1694022847e+05
R_Conv_1_12_8_1_2_2_0 L0_N1492 L1_N329 1.5663616684e+06
R_Conv_1_12_8_1_2_2_1 L0_N1493 L1_N329 2.1466641264e+05
*
R_Conv_1_12_9_0_0_0_0 L0_N1380 L1_N330 3.0927915375e+05
R_Conv_1_12_9_0_0_0_1 L0_N1381 L1_N330 3.6154472179e+05
R_Conv_1_12_9_0_0_1_0 L0_N1382 L1_N330 1.2307612303e+05
R_Conv_1_12_9_0_0_1_1 L0_N1383 L1_N330 1.3361401953e+06
R_Conv_1_12_9_0_0_2_0 L0_N1384 L1_N330 1.1771240850e+06
R_Conv_1_12_9_0_0_2_1 L0_N1385 L1_N330 1.1947062568e+05
R_Conv_1_12_9_0_1_0_0 L0_N1436 L1_N330 3.4555602430e+05
R_Conv_1_12_9_0_1_0_1 L0_N1437 L1_N330 1.2140655673e+05
R_Conv_1_12_9_0_1_1_0 L0_N1438 L1_N330 2.0024008865e+05
R_Conv_1_12_9_0_1_1_1 L0_N1439 L1_N330 1.3019124074e+05
R_Conv_1_12_9_0_1_2_0 L0_N1440 L1_N330 1.1085089352e+05
R_Conv_1_12_9_0_1_2_1 L0_N1441 L1_N330 2.5251460583e+05
R_Conv_1_12_9_0_2_0_0 L0_N1492 L1_N330 1.1040315248e+05
R_Conv_1_12_9_0_2_0_1 L0_N1493 L1_N330 1.2105931856e+05
R_Conv_1_12_9_0_2_1_0 L0_N1494 L1_N330 1.0186236681e+05
R_Conv_1_12_9_0_2_1_1 L0_N1495 L1_N330 3.8798345399e+05
R_Conv_1_12_9_0_2_2_0 L0_N1496 L1_N330 4.4022254443e+06
R_Conv_1_12_9_0_2_2_1 L0_N1497 L1_N330 1.5358515901e+05
*
R_Conv_1_12_9_1_0_0_0 L0_N1380 L1_N331 1.2123709737e+05
R_Conv_1_12_9_1_0_0_1 L0_N1381 L1_N331 1.0849154640e+05
R_Conv_1_12_9_1_0_1_0 L0_N1382 L1_N331 2.0480317885e+05
R_Conv_1_12_9_1_0_1_1 L0_N1383 L1_N331 1.6641635952e+05
R_Conv_1_12_9_1_0_2_0 L0_N1384 L1_N331 1.1683261279e+06
R_Conv_1_12_9_1_0_2_1 L0_N1385 L1_N331 1.1602008983e+05
R_Conv_1_12_9_1_1_0_0 L0_N1436 L1_N331 1.2296662853e+05
R_Conv_1_12_9_1_1_0_1 L0_N1437 L1_N331 1.6882235068e+05
R_Conv_1_12_9_1_1_1_0 L0_N1438 L1_N331 1.0472083211e+05
R_Conv_1_12_9_1_1_1_1 L0_N1439 L1_N331 2.1167619859e+05
R_Conv_1_12_9_1_1_2_0 L0_N1440 L1_N331 1.3518319025e+05
R_Conv_1_12_9_1_1_2_1 L0_N1441 L1_N331 1.4280846670e+05
R_Conv_1_12_9_1_2_0_0 L0_N1492 L1_N331 1.1620759255e+05
R_Conv_1_12_9_1_2_0_1 L0_N1493 L1_N331 1.6895116802e+05
R_Conv_1_12_9_1_2_1_0 L0_N1494 L1_N331 1.2455043512e+06
R_Conv_1_12_9_1_2_1_1 L0_N1495 L1_N331 1.1694022847e+05
R_Conv_1_12_9_1_2_2_0 L0_N1496 L1_N331 1.5663616684e+06
R_Conv_1_12_9_1_2_2_1 L0_N1497 L1_N331 2.1466641264e+05
*
R_Conv_1_12_10_0_0_0_0 L0_N1384 L1_N332 3.0927915375e+05
R_Conv_1_12_10_0_0_0_1 L0_N1385 L1_N332 3.6154472179e+05
R_Conv_1_12_10_0_0_1_0 L0_N1386 L1_N332 1.2307612303e+05
R_Conv_1_12_10_0_0_1_1 L0_N1387 L1_N332 1.3361401953e+06
R_Conv_1_12_10_0_0_2_0 L0_N1388 L1_N332 1.1771240850e+06
R_Conv_1_12_10_0_0_2_1 L0_N1389 L1_N332 1.1947062568e+05
R_Conv_1_12_10_0_1_0_0 L0_N1440 L1_N332 3.4555602430e+05
R_Conv_1_12_10_0_1_0_1 L0_N1441 L1_N332 1.2140655673e+05
R_Conv_1_12_10_0_1_1_0 L0_N1442 L1_N332 2.0024008865e+05
R_Conv_1_12_10_0_1_1_1 L0_N1443 L1_N332 1.3019124074e+05
R_Conv_1_12_10_0_1_2_0 L0_N1444 L1_N332 1.1085089352e+05
R_Conv_1_12_10_0_1_2_1 L0_N1445 L1_N332 2.5251460583e+05
R_Conv_1_12_10_0_2_0_0 L0_N1496 L1_N332 1.1040315248e+05
R_Conv_1_12_10_0_2_0_1 L0_N1497 L1_N332 1.2105931856e+05
R_Conv_1_12_10_0_2_1_0 L0_N1498 L1_N332 1.0186236681e+05
R_Conv_1_12_10_0_2_1_1 L0_N1499 L1_N332 3.8798345399e+05
R_Conv_1_12_10_0_2_2_0 L0_N1500 L1_N332 4.4022254443e+06
R_Conv_1_12_10_0_2_2_1 L0_N1501 L1_N332 1.5358515901e+05
*
R_Conv_1_12_10_1_0_0_0 L0_N1384 L1_N333 1.2123709737e+05
R_Conv_1_12_10_1_0_0_1 L0_N1385 L1_N333 1.0849154640e+05
R_Conv_1_12_10_1_0_1_0 L0_N1386 L1_N333 2.0480317885e+05
R_Conv_1_12_10_1_0_1_1 L0_N1387 L1_N333 1.6641635952e+05
R_Conv_1_12_10_1_0_2_0 L0_N1388 L1_N333 1.1683261279e+06
R_Conv_1_12_10_1_0_2_1 L0_N1389 L1_N333 1.1602008983e+05
R_Conv_1_12_10_1_1_0_0 L0_N1440 L1_N333 1.2296662853e+05
R_Conv_1_12_10_1_1_0_1 L0_N1441 L1_N333 1.6882235068e+05
R_Conv_1_12_10_1_1_1_0 L0_N1442 L1_N333 1.0472083211e+05
R_Conv_1_12_10_1_1_1_1 L0_N1443 L1_N333 2.1167619859e+05
R_Conv_1_12_10_1_1_2_0 L0_N1444 L1_N333 1.3518319025e+05
R_Conv_1_12_10_1_1_2_1 L0_N1445 L1_N333 1.4280846670e+05
R_Conv_1_12_10_1_2_0_0 L0_N1496 L1_N333 1.1620759255e+05
R_Conv_1_12_10_1_2_0_1 L0_N1497 L1_N333 1.6895116802e+05
R_Conv_1_12_10_1_2_1_0 L0_N1498 L1_N333 1.2455043512e+06
R_Conv_1_12_10_1_2_1_1 L0_N1499 L1_N333 1.1694022847e+05
R_Conv_1_12_10_1_2_2_0 L0_N1500 L1_N333 1.5663616684e+06
R_Conv_1_12_10_1_2_2_1 L0_N1501 L1_N333 2.1466641264e+05
*
R_Conv_1_12_11_0_0_0_0 L0_N1388 L1_N334 3.0927915375e+05
R_Conv_1_12_11_0_0_0_1 L0_N1389 L1_N334 3.6154472179e+05
R_Conv_1_12_11_0_0_1_0 L0_N1390 L1_N334 1.2307612303e+05
R_Conv_1_12_11_0_0_1_1 L0_N1391 L1_N334 1.3361401953e+06
R_Conv_1_12_11_0_0_2_0 L0_N1392 L1_N334 1.1771240850e+06
R_Conv_1_12_11_0_0_2_1 L0_N1393 L1_N334 1.1947062568e+05
R_Conv_1_12_11_0_1_0_0 L0_N1444 L1_N334 3.4555602430e+05
R_Conv_1_12_11_0_1_0_1 L0_N1445 L1_N334 1.2140655673e+05
R_Conv_1_12_11_0_1_1_0 L0_N1446 L1_N334 2.0024008865e+05
R_Conv_1_12_11_0_1_1_1 L0_N1447 L1_N334 1.3019124074e+05
R_Conv_1_12_11_0_1_2_0 L0_N1448 L1_N334 1.1085089352e+05
R_Conv_1_12_11_0_1_2_1 L0_N1449 L1_N334 2.5251460583e+05
R_Conv_1_12_11_0_2_0_0 L0_N1500 L1_N334 1.1040315248e+05
R_Conv_1_12_11_0_2_0_1 L0_N1501 L1_N334 1.2105931856e+05
R_Conv_1_12_11_0_2_1_0 L0_N1502 L1_N334 1.0186236681e+05
R_Conv_1_12_11_0_2_1_1 L0_N1503 L1_N334 3.8798345399e+05
R_Conv_1_12_11_0_2_2_0 L0_N1504 L1_N334 4.4022254443e+06
R_Conv_1_12_11_0_2_2_1 L0_N1505 L1_N334 1.5358515901e+05
*
R_Conv_1_12_11_1_0_0_0 L0_N1388 L1_N335 1.2123709737e+05
R_Conv_1_12_11_1_0_0_1 L0_N1389 L1_N335 1.0849154640e+05
R_Conv_1_12_11_1_0_1_0 L0_N1390 L1_N335 2.0480317885e+05
R_Conv_1_12_11_1_0_1_1 L0_N1391 L1_N335 1.6641635952e+05
R_Conv_1_12_11_1_0_2_0 L0_N1392 L1_N335 1.1683261279e+06
R_Conv_1_12_11_1_0_2_1 L0_N1393 L1_N335 1.1602008983e+05
R_Conv_1_12_11_1_1_0_0 L0_N1444 L1_N335 1.2296662853e+05
R_Conv_1_12_11_1_1_0_1 L0_N1445 L1_N335 1.6882235068e+05
R_Conv_1_12_11_1_1_1_0 L0_N1446 L1_N335 1.0472083211e+05
R_Conv_1_12_11_1_1_1_1 L0_N1447 L1_N335 2.1167619859e+05
R_Conv_1_12_11_1_1_2_0 L0_N1448 L1_N335 1.3518319025e+05
R_Conv_1_12_11_1_1_2_1 L0_N1449 L1_N335 1.4280846670e+05
R_Conv_1_12_11_1_2_0_0 L0_N1500 L1_N335 1.1620759255e+05
R_Conv_1_12_11_1_2_0_1 L0_N1501 L1_N335 1.6895116802e+05
R_Conv_1_12_11_1_2_1_0 L0_N1502 L1_N335 1.2455043512e+06
R_Conv_1_12_11_1_2_1_1 L0_N1503 L1_N335 1.1694022847e+05
R_Conv_1_12_11_1_2_2_0 L0_N1504 L1_N335 1.5663616684e+06
R_Conv_1_12_11_1_2_2_1 L0_N1505 L1_N335 2.1466641264e+05
*
R_Conv_1_12_12_0_0_0_0 L0_N1392 L1_N336 3.0927915375e+05
R_Conv_1_12_12_0_0_0_1 L0_N1393 L1_N336 3.6154472179e+05
R_Conv_1_12_12_0_0_1_0 L0_N1394 L1_N336 1.2307612303e+05
R_Conv_1_12_12_0_0_1_1 L0_N1395 L1_N336 1.3361401953e+06
R_Conv_1_12_12_0_0_2_0 L0_N1396 L1_N336 1.1771240850e+06
R_Conv_1_12_12_0_0_2_1 L0_N1397 L1_N336 1.1947062568e+05
R_Conv_1_12_12_0_1_0_0 L0_N1448 L1_N336 3.4555602430e+05
R_Conv_1_12_12_0_1_0_1 L0_N1449 L1_N336 1.2140655673e+05
R_Conv_1_12_12_0_1_1_0 L0_N1450 L1_N336 2.0024008865e+05
R_Conv_1_12_12_0_1_1_1 L0_N1451 L1_N336 1.3019124074e+05
R_Conv_1_12_12_0_1_2_0 L0_N1452 L1_N336 1.1085089352e+05
R_Conv_1_12_12_0_1_2_1 L0_N1453 L1_N336 2.5251460583e+05
R_Conv_1_12_12_0_2_0_0 L0_N1504 L1_N336 1.1040315248e+05
R_Conv_1_12_12_0_2_0_1 L0_N1505 L1_N336 1.2105931856e+05
R_Conv_1_12_12_0_2_1_0 L0_N1506 L1_N336 1.0186236681e+05
R_Conv_1_12_12_0_2_1_1 L0_N1507 L1_N336 3.8798345399e+05
R_Conv_1_12_12_0_2_2_0 L0_N1508 L1_N336 4.4022254443e+06
R_Conv_1_12_12_0_2_2_1 L0_N1509 L1_N336 1.5358515901e+05
*
R_Conv_1_12_12_1_0_0_0 L0_N1392 L1_N337 1.2123709737e+05
R_Conv_1_12_12_1_0_0_1 L0_N1393 L1_N337 1.0849154640e+05
R_Conv_1_12_12_1_0_1_0 L0_N1394 L1_N337 2.0480317885e+05
R_Conv_1_12_12_1_0_1_1 L0_N1395 L1_N337 1.6641635952e+05
R_Conv_1_12_12_1_0_2_0 L0_N1396 L1_N337 1.1683261279e+06
R_Conv_1_12_12_1_0_2_1 L0_N1397 L1_N337 1.1602008983e+05
R_Conv_1_12_12_1_1_0_0 L0_N1448 L1_N337 1.2296662853e+05
R_Conv_1_12_12_1_1_0_1 L0_N1449 L1_N337 1.6882235068e+05
R_Conv_1_12_12_1_1_1_0 L0_N1450 L1_N337 1.0472083211e+05
R_Conv_1_12_12_1_1_1_1 L0_N1451 L1_N337 2.1167619859e+05
R_Conv_1_12_12_1_1_2_0 L0_N1452 L1_N337 1.3518319025e+05
R_Conv_1_12_12_1_1_2_1 L0_N1453 L1_N337 1.4280846670e+05
R_Conv_1_12_12_1_2_0_0 L0_N1504 L1_N337 1.1620759255e+05
R_Conv_1_12_12_1_2_0_1 L0_N1505 L1_N337 1.6895116802e+05
R_Conv_1_12_12_1_2_1_0 L0_N1506 L1_N337 1.2455043512e+06
R_Conv_1_12_12_1_2_1_1 L0_N1507 L1_N337 1.1694022847e+05
R_Conv_1_12_12_1_2_2_0 L0_N1508 L1_N337 1.5663616684e+06
R_Conv_1_12_12_1_2_2_1 L0_N1509 L1_N337 2.1466641264e+05
Bd1d_0 L1_N0 0 I={ max(((V(L1_N0) - 0.01)/1e+20), ((V(L1_N0) - 0.01)/1.0)) }
Bd1u_0 L1_N0 0 I={ min(((V(L1_N0) + 0.01)/1e+20), ((V(L1_N0) + 0.01)/1.0)) }
Bd1d_1 L1_N1 0 I={ max(((V(L1_N1) - 0.01)/1e+20), ((V(L1_N1) - 0.01)/1.0)) }
Bd1u_1 L1_N1 0 I={ min(((V(L1_N1) + 0.01)/1e+20), ((V(L1_N1) + 0.01)/1.0)) }
Bd1d_2 L1_N2 0 I={ max(((V(L1_N2) - 0.01)/1e+20), ((V(L1_N2) - 0.01)/1.0)) }
Bd1u_2 L1_N2 0 I={ min(((V(L1_N2) + 0.01)/1e+20), ((V(L1_N2) + 0.01)/1.0)) }
Bd1d_3 L1_N3 0 I={ max(((V(L1_N3) - 0.01)/1e+20), ((V(L1_N3) - 0.01)/1.0)) }
Bd1u_3 L1_N3 0 I={ min(((V(L1_N3) + 0.01)/1e+20), ((V(L1_N3) + 0.01)/1.0)) }
Bd1d_4 L1_N4 0 I={ max(((V(L1_N4) - 0.01)/1e+20), ((V(L1_N4) - 0.01)/1.0)) }
Bd1u_4 L1_N4 0 I={ min(((V(L1_N4) + 0.01)/1e+20), ((V(L1_N4) + 0.01)/1.0)) }
Bd1d_5 L1_N5 0 I={ max(((V(L1_N5) - 0.01)/1e+20), ((V(L1_N5) - 0.01)/1.0)) }
Bd1u_5 L1_N5 0 I={ min(((V(L1_N5) + 0.01)/1e+20), ((V(L1_N5) + 0.01)/1.0)) }
Bd1d_6 L1_N6 0 I={ max(((V(L1_N6) - 0.01)/1e+20), ((V(L1_N6) - 0.01)/1.0)) }
Bd1u_6 L1_N6 0 I={ min(((V(L1_N6) + 0.01)/1e+20), ((V(L1_N6) + 0.01)/1.0)) }
Bd1d_7 L1_N7 0 I={ max(((V(L1_N7) - 0.01)/1e+20), ((V(L1_N7) - 0.01)/1.0)) }
Bd1u_7 L1_N7 0 I={ min(((V(L1_N7) + 0.01)/1e+20), ((V(L1_N7) + 0.01)/1.0)) }
Bd1d_8 L1_N8 0 I={ max(((V(L1_N8) - 0.01)/1e+20), ((V(L1_N8) - 0.01)/1.0)) }
Bd1u_8 L1_N8 0 I={ min(((V(L1_N8) + 0.01)/1e+20), ((V(L1_N8) + 0.01)/1.0)) }
Bd1d_9 L1_N9 0 I={ max(((V(L1_N9) - 0.01)/1e+20), ((V(L1_N9) - 0.01)/1.0)) }
Bd1u_9 L1_N9 0 I={ min(((V(L1_N9) + 0.01)/1e+20), ((V(L1_N9) + 0.01)/1.0)) }
Bd1d_10 L1_N10 0 I={ max(((V(L1_N10) - 0.01)/1e+20), ((V(L1_N10) - 0.01)/1.0)) }
Bd1u_10 L1_N10 0 I={ min(((V(L1_N10) + 0.01)/1e+20), ((V(L1_N10) + 0.01)/1.0)) }
Bd1d_11 L1_N11 0 I={ max(((V(L1_N11) - 0.01)/1e+20), ((V(L1_N11) - 0.01)/1.0)) }
Bd1u_11 L1_N11 0 I={ min(((V(L1_N11) + 0.01)/1e+20), ((V(L1_N11) + 0.01)/1.0)) }
Bd1d_12 L1_N12 0 I={ max(((V(L1_N12) - 0.01)/1e+20), ((V(L1_N12) - 0.01)/1.0)) }
Bd1u_12 L1_N12 0 I={ min(((V(L1_N12) + 0.01)/1e+20), ((V(L1_N12) + 0.01)/1.0)) }
Bd1d_13 L1_N13 0 I={ max(((V(L1_N13) - 0.01)/1e+20), ((V(L1_N13) - 0.01)/1.0)) }
Bd1u_13 L1_N13 0 I={ min(((V(L1_N13) + 0.01)/1e+20), ((V(L1_N13) + 0.01)/1.0)) }
Bd1d_14 L1_N14 0 I={ max(((V(L1_N14) - 0.01)/1e+20), ((V(L1_N14) - 0.01)/1.0)) }
Bd1u_14 L1_N14 0 I={ min(((V(L1_N14) + 0.01)/1e+20), ((V(L1_N14) + 0.01)/1.0)) }
Bd1d_15 L1_N15 0 I={ max(((V(L1_N15) - 0.01)/1e+20), ((V(L1_N15) - 0.01)/1.0)) }
Bd1u_15 L1_N15 0 I={ min(((V(L1_N15) + 0.01)/1e+20), ((V(L1_N15) + 0.01)/1.0)) }
Bd1d_16 L1_N16 0 I={ max(((V(L1_N16) - 0.01)/1e+20), ((V(L1_N16) - 0.01)/1.0)) }
Bd1u_16 L1_N16 0 I={ min(((V(L1_N16) + 0.01)/1e+20), ((V(L1_N16) + 0.01)/1.0)) }
Bd1d_17 L1_N17 0 I={ max(((V(L1_N17) - 0.01)/1e+20), ((V(L1_N17) - 0.01)/1.0)) }
Bd1u_17 L1_N17 0 I={ min(((V(L1_N17) + 0.01)/1e+20), ((V(L1_N17) + 0.01)/1.0)) }
Bd1d_18 L1_N18 0 I={ max(((V(L1_N18) - 0.01)/1e+20), ((V(L1_N18) - 0.01)/1.0)) }
Bd1u_18 L1_N18 0 I={ min(((V(L1_N18) + 0.01)/1e+20), ((V(L1_N18) + 0.01)/1.0)) }
Bd1d_19 L1_N19 0 I={ max(((V(L1_N19) - 0.01)/1e+20), ((V(L1_N19) - 0.01)/1.0)) }
Bd1u_19 L1_N19 0 I={ min(((V(L1_N19) + 0.01)/1e+20), ((V(L1_N19) + 0.01)/1.0)) }
Bd1d_20 L1_N20 0 I={ max(((V(L1_N20) - 0.01)/1e+20), ((V(L1_N20) - 0.01)/1.0)) }
Bd1u_20 L1_N20 0 I={ min(((V(L1_N20) + 0.01)/1e+20), ((V(L1_N20) + 0.01)/1.0)) }
Bd1d_21 L1_N21 0 I={ max(((V(L1_N21) - 0.01)/1e+20), ((V(L1_N21) - 0.01)/1.0)) }
Bd1u_21 L1_N21 0 I={ min(((V(L1_N21) + 0.01)/1e+20), ((V(L1_N21) + 0.01)/1.0)) }
Bd1d_22 L1_N22 0 I={ max(((V(L1_N22) - 0.01)/1e+20), ((V(L1_N22) - 0.01)/1.0)) }
Bd1u_22 L1_N22 0 I={ min(((V(L1_N22) + 0.01)/1e+20), ((V(L1_N22) + 0.01)/1.0)) }
Bd1d_23 L1_N23 0 I={ max(((V(L1_N23) - 0.01)/1e+20), ((V(L1_N23) - 0.01)/1.0)) }
Bd1u_23 L1_N23 0 I={ min(((V(L1_N23) + 0.01)/1e+20), ((V(L1_N23) + 0.01)/1.0)) }
Bd1d_24 L1_N24 0 I={ max(((V(L1_N24) - 0.01)/1e+20), ((V(L1_N24) - 0.01)/1.0)) }
Bd1u_24 L1_N24 0 I={ min(((V(L1_N24) + 0.01)/1e+20), ((V(L1_N24) + 0.01)/1.0)) }
Bd1d_25 L1_N25 0 I={ max(((V(L1_N25) - 0.01)/1e+20), ((V(L1_N25) - 0.01)/1.0)) }
Bd1u_25 L1_N25 0 I={ min(((V(L1_N25) + 0.01)/1e+20), ((V(L1_N25) + 0.01)/1.0)) }
Bd1d_26 L1_N26 0 I={ max(((V(L1_N26) - 0.01)/1e+20), ((V(L1_N26) - 0.01)/1.0)) }
Bd1u_26 L1_N26 0 I={ min(((V(L1_N26) + 0.01)/1e+20), ((V(L1_N26) + 0.01)/1.0)) }
Bd1d_27 L1_N27 0 I={ max(((V(L1_N27) - 0.01)/1e+20), ((V(L1_N27) - 0.01)/1.0)) }
Bd1u_27 L1_N27 0 I={ min(((V(L1_N27) + 0.01)/1e+20), ((V(L1_N27) + 0.01)/1.0)) }
Bd1d_28 L1_N28 0 I={ max(((V(L1_N28) - 0.01)/1e+20), ((V(L1_N28) - 0.01)/1.0)) }
Bd1u_28 L1_N28 0 I={ min(((V(L1_N28) + 0.01)/1e+20), ((V(L1_N28) + 0.01)/1.0)) }
Bd1d_29 L1_N29 0 I={ max(((V(L1_N29) - 0.01)/1e+20), ((V(L1_N29) - 0.01)/1.0)) }
Bd1u_29 L1_N29 0 I={ min(((V(L1_N29) + 0.01)/1e+20), ((V(L1_N29) + 0.01)/1.0)) }
Bd1d_30 L1_N30 0 I={ max(((V(L1_N30) - 0.01)/1e+20), ((V(L1_N30) - 0.01)/1.0)) }
Bd1u_30 L1_N30 0 I={ min(((V(L1_N30) + 0.01)/1e+20), ((V(L1_N30) + 0.01)/1.0)) }
Bd1d_31 L1_N31 0 I={ max(((V(L1_N31) - 0.01)/1e+20), ((V(L1_N31) - 0.01)/1.0)) }
Bd1u_31 L1_N31 0 I={ min(((V(L1_N31) + 0.01)/1e+20), ((V(L1_N31) + 0.01)/1.0)) }
Bd1d_32 L1_N32 0 I={ max(((V(L1_N32) - 0.01)/1e+20), ((V(L1_N32) - 0.01)/1.0)) }
Bd1u_32 L1_N32 0 I={ min(((V(L1_N32) + 0.01)/1e+20), ((V(L1_N32) + 0.01)/1.0)) }
Bd1d_33 L1_N33 0 I={ max(((V(L1_N33) - 0.01)/1e+20), ((V(L1_N33) - 0.01)/1.0)) }
Bd1u_33 L1_N33 0 I={ min(((V(L1_N33) + 0.01)/1e+20), ((V(L1_N33) + 0.01)/1.0)) }
Bd1d_34 L1_N34 0 I={ max(((V(L1_N34) - 0.01)/1e+20), ((V(L1_N34) - 0.01)/1.0)) }
Bd1u_34 L1_N34 0 I={ min(((V(L1_N34) + 0.01)/1e+20), ((V(L1_N34) + 0.01)/1.0)) }
Bd1d_35 L1_N35 0 I={ max(((V(L1_N35) - 0.01)/1e+20), ((V(L1_N35) - 0.01)/1.0)) }
Bd1u_35 L1_N35 0 I={ min(((V(L1_N35) + 0.01)/1e+20), ((V(L1_N35) + 0.01)/1.0)) }
Bd1d_36 L1_N36 0 I={ max(((V(L1_N36) - 0.01)/1e+20), ((V(L1_N36) - 0.01)/1.0)) }
Bd1u_36 L1_N36 0 I={ min(((V(L1_N36) + 0.01)/1e+20), ((V(L1_N36) + 0.01)/1.0)) }
Bd1d_37 L1_N37 0 I={ max(((V(L1_N37) - 0.01)/1e+20), ((V(L1_N37) - 0.01)/1.0)) }
Bd1u_37 L1_N37 0 I={ min(((V(L1_N37) + 0.01)/1e+20), ((V(L1_N37) + 0.01)/1.0)) }
Bd1d_38 L1_N38 0 I={ max(((V(L1_N38) - 0.01)/1e+20), ((V(L1_N38) - 0.01)/1.0)) }
Bd1u_38 L1_N38 0 I={ min(((V(L1_N38) + 0.01)/1e+20), ((V(L1_N38) + 0.01)/1.0)) }
Bd1d_39 L1_N39 0 I={ max(((V(L1_N39) - 0.01)/1e+20), ((V(L1_N39) - 0.01)/1.0)) }
Bd1u_39 L1_N39 0 I={ min(((V(L1_N39) + 0.01)/1e+20), ((V(L1_N39) + 0.01)/1.0)) }
Bd1d_40 L1_N40 0 I={ max(((V(L1_N40) - 0.01)/1e+20), ((V(L1_N40) - 0.01)/1.0)) }
Bd1u_40 L1_N40 0 I={ min(((V(L1_N40) + 0.01)/1e+20), ((V(L1_N40) + 0.01)/1.0)) }
Bd1d_41 L1_N41 0 I={ max(((V(L1_N41) - 0.01)/1e+20), ((V(L1_N41) - 0.01)/1.0)) }
Bd1u_41 L1_N41 0 I={ min(((V(L1_N41) + 0.01)/1e+20), ((V(L1_N41) + 0.01)/1.0)) }
Bd1d_42 L1_N42 0 I={ max(((V(L1_N42) - 0.01)/1e+20), ((V(L1_N42) - 0.01)/1.0)) }
Bd1u_42 L1_N42 0 I={ min(((V(L1_N42) + 0.01)/1e+20), ((V(L1_N42) + 0.01)/1.0)) }
Bd1d_43 L1_N43 0 I={ max(((V(L1_N43) - 0.01)/1e+20), ((V(L1_N43) - 0.01)/1.0)) }
Bd1u_43 L1_N43 0 I={ min(((V(L1_N43) + 0.01)/1e+20), ((V(L1_N43) + 0.01)/1.0)) }
Bd1d_44 L1_N44 0 I={ max(((V(L1_N44) - 0.01)/1e+20), ((V(L1_N44) - 0.01)/1.0)) }
Bd1u_44 L1_N44 0 I={ min(((V(L1_N44) + 0.01)/1e+20), ((V(L1_N44) + 0.01)/1.0)) }
Bd1d_45 L1_N45 0 I={ max(((V(L1_N45) - 0.01)/1e+20), ((V(L1_N45) - 0.01)/1.0)) }
Bd1u_45 L1_N45 0 I={ min(((V(L1_N45) + 0.01)/1e+20), ((V(L1_N45) + 0.01)/1.0)) }
Bd1d_46 L1_N46 0 I={ max(((V(L1_N46) - 0.01)/1e+20), ((V(L1_N46) - 0.01)/1.0)) }
Bd1u_46 L1_N46 0 I={ min(((V(L1_N46) + 0.01)/1e+20), ((V(L1_N46) + 0.01)/1.0)) }
Bd1d_47 L1_N47 0 I={ max(((V(L1_N47) - 0.01)/1e+20), ((V(L1_N47) - 0.01)/1.0)) }
Bd1u_47 L1_N47 0 I={ min(((V(L1_N47) + 0.01)/1e+20), ((V(L1_N47) + 0.01)/1.0)) }
Bd1d_48 L1_N48 0 I={ max(((V(L1_N48) - 0.01)/1e+20), ((V(L1_N48) - 0.01)/1.0)) }
Bd1u_48 L1_N48 0 I={ min(((V(L1_N48) + 0.01)/1e+20), ((V(L1_N48) + 0.01)/1.0)) }
Bd1d_49 L1_N49 0 I={ max(((V(L1_N49) - 0.01)/1e+20), ((V(L1_N49) - 0.01)/1.0)) }
Bd1u_49 L1_N49 0 I={ min(((V(L1_N49) + 0.01)/1e+20), ((V(L1_N49) + 0.01)/1.0)) }
Bd1d_50 L1_N50 0 I={ max(((V(L1_N50) - 0.01)/1e+20), ((V(L1_N50) - 0.01)/1.0)) }
Bd1u_50 L1_N50 0 I={ min(((V(L1_N50) + 0.01)/1e+20), ((V(L1_N50) + 0.01)/1.0)) }
Bd1d_51 L1_N51 0 I={ max(((V(L1_N51) - 0.01)/1e+20), ((V(L1_N51) - 0.01)/1.0)) }
Bd1u_51 L1_N51 0 I={ min(((V(L1_N51) + 0.01)/1e+20), ((V(L1_N51) + 0.01)/1.0)) }
Bd1d_52 L1_N52 0 I={ max(((V(L1_N52) - 0.01)/1e+20), ((V(L1_N52) - 0.01)/1.0)) }
Bd1u_52 L1_N52 0 I={ min(((V(L1_N52) + 0.01)/1e+20), ((V(L1_N52) + 0.01)/1.0)) }
Bd1d_53 L1_N53 0 I={ max(((V(L1_N53) - 0.01)/1e+20), ((V(L1_N53) - 0.01)/1.0)) }
Bd1u_53 L1_N53 0 I={ min(((V(L1_N53) + 0.01)/1e+20), ((V(L1_N53) + 0.01)/1.0)) }
Bd1d_54 L1_N54 0 I={ max(((V(L1_N54) - 0.01)/1e+20), ((V(L1_N54) - 0.01)/1.0)) }
Bd1u_54 L1_N54 0 I={ min(((V(L1_N54) + 0.01)/1e+20), ((V(L1_N54) + 0.01)/1.0)) }
Bd1d_55 L1_N55 0 I={ max(((V(L1_N55) - 0.01)/1e+20), ((V(L1_N55) - 0.01)/1.0)) }
Bd1u_55 L1_N55 0 I={ min(((V(L1_N55) + 0.01)/1e+20), ((V(L1_N55) + 0.01)/1.0)) }
Bd1d_56 L1_N56 0 I={ max(((V(L1_N56) - 0.01)/1e+20), ((V(L1_N56) - 0.01)/1.0)) }
Bd1u_56 L1_N56 0 I={ min(((V(L1_N56) + 0.01)/1e+20), ((V(L1_N56) + 0.01)/1.0)) }
Bd1d_57 L1_N57 0 I={ max(((V(L1_N57) - 0.01)/1e+20), ((V(L1_N57) - 0.01)/1.0)) }
Bd1u_57 L1_N57 0 I={ min(((V(L1_N57) + 0.01)/1e+20), ((V(L1_N57) + 0.01)/1.0)) }
Bd1d_58 L1_N58 0 I={ max(((V(L1_N58) - 0.01)/1e+20), ((V(L1_N58) - 0.01)/1.0)) }
Bd1u_58 L1_N58 0 I={ min(((V(L1_N58) + 0.01)/1e+20), ((V(L1_N58) + 0.01)/1.0)) }
Bd1d_59 L1_N59 0 I={ max(((V(L1_N59) - 0.01)/1e+20), ((V(L1_N59) - 0.01)/1.0)) }
Bd1u_59 L1_N59 0 I={ min(((V(L1_N59) + 0.01)/1e+20), ((V(L1_N59) + 0.01)/1.0)) }
Bd1d_60 L1_N60 0 I={ max(((V(L1_N60) - 0.01)/1e+20), ((V(L1_N60) - 0.01)/1.0)) }
Bd1u_60 L1_N60 0 I={ min(((V(L1_N60) + 0.01)/1e+20), ((V(L1_N60) + 0.01)/1.0)) }
Bd1d_61 L1_N61 0 I={ max(((V(L1_N61) - 0.01)/1e+20), ((V(L1_N61) - 0.01)/1.0)) }
Bd1u_61 L1_N61 0 I={ min(((V(L1_N61) + 0.01)/1e+20), ((V(L1_N61) + 0.01)/1.0)) }
Bd1d_62 L1_N62 0 I={ max(((V(L1_N62) - 0.01)/1e+20), ((V(L1_N62) - 0.01)/1.0)) }
Bd1u_62 L1_N62 0 I={ min(((V(L1_N62) + 0.01)/1e+20), ((V(L1_N62) + 0.01)/1.0)) }
Bd1d_63 L1_N63 0 I={ max(((V(L1_N63) - 0.01)/1e+20), ((V(L1_N63) - 0.01)/1.0)) }
Bd1u_63 L1_N63 0 I={ min(((V(L1_N63) + 0.01)/1e+20), ((V(L1_N63) + 0.01)/1.0)) }
Bd1d_64 L1_N64 0 I={ max(((V(L1_N64) - 0.01)/1e+20), ((V(L1_N64) - 0.01)/1.0)) }
Bd1u_64 L1_N64 0 I={ min(((V(L1_N64) + 0.01)/1e+20), ((V(L1_N64) + 0.01)/1.0)) }
Bd1d_65 L1_N65 0 I={ max(((V(L1_N65) - 0.01)/1e+20), ((V(L1_N65) - 0.01)/1.0)) }
Bd1u_65 L1_N65 0 I={ min(((V(L1_N65) + 0.01)/1e+20), ((V(L1_N65) + 0.01)/1.0)) }
Bd1d_66 L1_N66 0 I={ max(((V(L1_N66) - 0.01)/1e+20), ((V(L1_N66) - 0.01)/1.0)) }
Bd1u_66 L1_N66 0 I={ min(((V(L1_N66) + 0.01)/1e+20), ((V(L1_N66) + 0.01)/1.0)) }
Bd1d_67 L1_N67 0 I={ max(((V(L1_N67) - 0.01)/1e+20), ((V(L1_N67) - 0.01)/1.0)) }
Bd1u_67 L1_N67 0 I={ min(((V(L1_N67) + 0.01)/1e+20), ((V(L1_N67) + 0.01)/1.0)) }
Bd1d_68 L1_N68 0 I={ max(((V(L1_N68) - 0.01)/1e+20), ((V(L1_N68) - 0.01)/1.0)) }
Bd1u_68 L1_N68 0 I={ min(((V(L1_N68) + 0.01)/1e+20), ((V(L1_N68) + 0.01)/1.0)) }
Bd1d_69 L1_N69 0 I={ max(((V(L1_N69) - 0.01)/1e+20), ((V(L1_N69) - 0.01)/1.0)) }
Bd1u_69 L1_N69 0 I={ min(((V(L1_N69) + 0.01)/1e+20), ((V(L1_N69) + 0.01)/1.0)) }
Bd1d_70 L1_N70 0 I={ max(((V(L1_N70) - 0.01)/1e+20), ((V(L1_N70) - 0.01)/1.0)) }
Bd1u_70 L1_N70 0 I={ min(((V(L1_N70) + 0.01)/1e+20), ((V(L1_N70) + 0.01)/1.0)) }
Bd1d_71 L1_N71 0 I={ max(((V(L1_N71) - 0.01)/1e+20), ((V(L1_N71) - 0.01)/1.0)) }
Bd1u_71 L1_N71 0 I={ min(((V(L1_N71) + 0.01)/1e+20), ((V(L1_N71) + 0.01)/1.0)) }
Bd1d_72 L1_N72 0 I={ max(((V(L1_N72) - 0.01)/1e+20), ((V(L1_N72) - 0.01)/1.0)) }
Bd1u_72 L1_N72 0 I={ min(((V(L1_N72) + 0.01)/1e+20), ((V(L1_N72) + 0.01)/1.0)) }
Bd1d_73 L1_N73 0 I={ max(((V(L1_N73) - 0.01)/1e+20), ((V(L1_N73) - 0.01)/1.0)) }
Bd1u_73 L1_N73 0 I={ min(((V(L1_N73) + 0.01)/1e+20), ((V(L1_N73) + 0.01)/1.0)) }
Bd1d_74 L1_N74 0 I={ max(((V(L1_N74) - 0.01)/1e+20), ((V(L1_N74) - 0.01)/1.0)) }
Bd1u_74 L1_N74 0 I={ min(((V(L1_N74) + 0.01)/1e+20), ((V(L1_N74) + 0.01)/1.0)) }
Bd1d_75 L1_N75 0 I={ max(((V(L1_N75) - 0.01)/1e+20), ((V(L1_N75) - 0.01)/1.0)) }
Bd1u_75 L1_N75 0 I={ min(((V(L1_N75) + 0.01)/1e+20), ((V(L1_N75) + 0.01)/1.0)) }
Bd1d_76 L1_N76 0 I={ max(((V(L1_N76) - 0.01)/1e+20), ((V(L1_N76) - 0.01)/1.0)) }
Bd1u_76 L1_N76 0 I={ min(((V(L1_N76) + 0.01)/1e+20), ((V(L1_N76) + 0.01)/1.0)) }
Bd1d_77 L1_N77 0 I={ max(((V(L1_N77) - 0.01)/1e+20), ((V(L1_N77) - 0.01)/1.0)) }
Bd1u_77 L1_N77 0 I={ min(((V(L1_N77) + 0.01)/1e+20), ((V(L1_N77) + 0.01)/1.0)) }
Bd1d_78 L1_N78 0 I={ max(((V(L1_N78) - 0.01)/1e+20), ((V(L1_N78) - 0.01)/1.0)) }
Bd1u_78 L1_N78 0 I={ min(((V(L1_N78) + 0.01)/1e+20), ((V(L1_N78) + 0.01)/1.0)) }
Bd1d_79 L1_N79 0 I={ max(((V(L1_N79) - 0.01)/1e+20), ((V(L1_N79) - 0.01)/1.0)) }
Bd1u_79 L1_N79 0 I={ min(((V(L1_N79) + 0.01)/1e+20), ((V(L1_N79) + 0.01)/1.0)) }
Bd1d_80 L1_N80 0 I={ max(((V(L1_N80) - 0.01)/1e+20), ((V(L1_N80) - 0.01)/1.0)) }
Bd1u_80 L1_N80 0 I={ min(((V(L1_N80) + 0.01)/1e+20), ((V(L1_N80) + 0.01)/1.0)) }
Bd1d_81 L1_N81 0 I={ max(((V(L1_N81) - 0.01)/1e+20), ((V(L1_N81) - 0.01)/1.0)) }
Bd1u_81 L1_N81 0 I={ min(((V(L1_N81) + 0.01)/1e+20), ((V(L1_N81) + 0.01)/1.0)) }
Bd1d_82 L1_N82 0 I={ max(((V(L1_N82) - 0.01)/1e+20), ((V(L1_N82) - 0.01)/1.0)) }
Bd1u_82 L1_N82 0 I={ min(((V(L1_N82) + 0.01)/1e+20), ((V(L1_N82) + 0.01)/1.0)) }
Bd1d_83 L1_N83 0 I={ max(((V(L1_N83) - 0.01)/1e+20), ((V(L1_N83) - 0.01)/1.0)) }
Bd1u_83 L1_N83 0 I={ min(((V(L1_N83) + 0.01)/1e+20), ((V(L1_N83) + 0.01)/1.0)) }
Bd1d_84 L1_N84 0 I={ max(((V(L1_N84) - 0.01)/1e+20), ((V(L1_N84) - 0.01)/1.0)) }
Bd1u_84 L1_N84 0 I={ min(((V(L1_N84) + 0.01)/1e+20), ((V(L1_N84) + 0.01)/1.0)) }
Bd1d_85 L1_N85 0 I={ max(((V(L1_N85) - 0.01)/1e+20), ((V(L1_N85) - 0.01)/1.0)) }
Bd1u_85 L1_N85 0 I={ min(((V(L1_N85) + 0.01)/1e+20), ((V(L1_N85) + 0.01)/1.0)) }
Bd1d_86 L1_N86 0 I={ max(((V(L1_N86) - 0.01)/1e+20), ((V(L1_N86) - 0.01)/1.0)) }
Bd1u_86 L1_N86 0 I={ min(((V(L1_N86) + 0.01)/1e+20), ((V(L1_N86) + 0.01)/1.0)) }
Bd1d_87 L1_N87 0 I={ max(((V(L1_N87) - 0.01)/1e+20), ((V(L1_N87) - 0.01)/1.0)) }
Bd1u_87 L1_N87 0 I={ min(((V(L1_N87) + 0.01)/1e+20), ((V(L1_N87) + 0.01)/1.0)) }
Bd1d_88 L1_N88 0 I={ max(((V(L1_N88) - 0.01)/1e+20), ((V(L1_N88) - 0.01)/1.0)) }
Bd1u_88 L1_N88 0 I={ min(((V(L1_N88) + 0.01)/1e+20), ((V(L1_N88) + 0.01)/1.0)) }
Bd1d_89 L1_N89 0 I={ max(((V(L1_N89) - 0.01)/1e+20), ((V(L1_N89) - 0.01)/1.0)) }
Bd1u_89 L1_N89 0 I={ min(((V(L1_N89) + 0.01)/1e+20), ((V(L1_N89) + 0.01)/1.0)) }
Bd1d_90 L1_N90 0 I={ max(((V(L1_N90) - 0.01)/1e+20), ((V(L1_N90) - 0.01)/1.0)) }
Bd1u_90 L1_N90 0 I={ min(((V(L1_N90) + 0.01)/1e+20), ((V(L1_N90) + 0.01)/1.0)) }
Bd1d_91 L1_N91 0 I={ max(((V(L1_N91) - 0.01)/1e+20), ((V(L1_N91) - 0.01)/1.0)) }
Bd1u_91 L1_N91 0 I={ min(((V(L1_N91) + 0.01)/1e+20), ((V(L1_N91) + 0.01)/1.0)) }
Bd1d_92 L1_N92 0 I={ max(((V(L1_N92) - 0.01)/1e+20), ((V(L1_N92) - 0.01)/1.0)) }
Bd1u_92 L1_N92 0 I={ min(((V(L1_N92) + 0.01)/1e+20), ((V(L1_N92) + 0.01)/1.0)) }
Bd1d_93 L1_N93 0 I={ max(((V(L1_N93) - 0.01)/1e+20), ((V(L1_N93) - 0.01)/1.0)) }
Bd1u_93 L1_N93 0 I={ min(((V(L1_N93) + 0.01)/1e+20), ((V(L1_N93) + 0.01)/1.0)) }
Bd1d_94 L1_N94 0 I={ max(((V(L1_N94) - 0.01)/1e+20), ((V(L1_N94) - 0.01)/1.0)) }
Bd1u_94 L1_N94 0 I={ min(((V(L1_N94) + 0.01)/1e+20), ((V(L1_N94) + 0.01)/1.0)) }
Bd1d_95 L1_N95 0 I={ max(((V(L1_N95) - 0.01)/1e+20), ((V(L1_N95) - 0.01)/1.0)) }
Bd1u_95 L1_N95 0 I={ min(((V(L1_N95) + 0.01)/1e+20), ((V(L1_N95) + 0.01)/1.0)) }
Bd1d_96 L1_N96 0 I={ max(((V(L1_N96) - 0.01)/1e+20), ((V(L1_N96) - 0.01)/1.0)) }
Bd1u_96 L1_N96 0 I={ min(((V(L1_N96) + 0.01)/1e+20), ((V(L1_N96) + 0.01)/1.0)) }
Bd1d_97 L1_N97 0 I={ max(((V(L1_N97) - 0.01)/1e+20), ((V(L1_N97) - 0.01)/1.0)) }
Bd1u_97 L1_N97 0 I={ min(((V(L1_N97) + 0.01)/1e+20), ((V(L1_N97) + 0.01)/1.0)) }
Bd1d_98 L1_N98 0 I={ max(((V(L1_N98) - 0.01)/1e+20), ((V(L1_N98) - 0.01)/1.0)) }
Bd1u_98 L1_N98 0 I={ min(((V(L1_N98) + 0.01)/1e+20), ((V(L1_N98) + 0.01)/1.0)) }
Bd1d_99 L1_N99 0 I={ max(((V(L1_N99) - 0.01)/1e+20), ((V(L1_N99) - 0.01)/1.0)) }
Bd1u_99 L1_N99 0 I={ min(((V(L1_N99) + 0.01)/1e+20), ((V(L1_N99) + 0.01)/1.0)) }
Bd1d_100 L1_N100 0 I={ max(((V(L1_N100) - 0.01)/1e+20), ((V(L1_N100) - 0.01)/1.0)) }
Bd1u_100 L1_N100 0 I={ min(((V(L1_N100) + 0.01)/1e+20), ((V(L1_N100) + 0.01)/1.0)) }
Bd1d_101 L1_N101 0 I={ max(((V(L1_N101) - 0.01)/1e+20), ((V(L1_N101) - 0.01)/1.0)) }
Bd1u_101 L1_N101 0 I={ min(((V(L1_N101) + 0.01)/1e+20), ((V(L1_N101) + 0.01)/1.0)) }
Bd1d_102 L1_N102 0 I={ max(((V(L1_N102) - 0.01)/1e+20), ((V(L1_N102) - 0.01)/1.0)) }
Bd1u_102 L1_N102 0 I={ min(((V(L1_N102) + 0.01)/1e+20), ((V(L1_N102) + 0.01)/1.0)) }
Bd1d_103 L1_N103 0 I={ max(((V(L1_N103) - 0.01)/1e+20), ((V(L1_N103) - 0.01)/1.0)) }
Bd1u_103 L1_N103 0 I={ min(((V(L1_N103) + 0.01)/1e+20), ((V(L1_N103) + 0.01)/1.0)) }
Bd1d_104 L1_N104 0 I={ max(((V(L1_N104) - 0.01)/1e+20), ((V(L1_N104) - 0.01)/1.0)) }
Bd1u_104 L1_N104 0 I={ min(((V(L1_N104) + 0.01)/1e+20), ((V(L1_N104) + 0.01)/1.0)) }
Bd1d_105 L1_N105 0 I={ max(((V(L1_N105) - 0.01)/1e+20), ((V(L1_N105) - 0.01)/1.0)) }
Bd1u_105 L1_N105 0 I={ min(((V(L1_N105) + 0.01)/1e+20), ((V(L1_N105) + 0.01)/1.0)) }
Bd1d_106 L1_N106 0 I={ max(((V(L1_N106) - 0.01)/1e+20), ((V(L1_N106) - 0.01)/1.0)) }
Bd1u_106 L1_N106 0 I={ min(((V(L1_N106) + 0.01)/1e+20), ((V(L1_N106) + 0.01)/1.0)) }
Bd1d_107 L1_N107 0 I={ max(((V(L1_N107) - 0.01)/1e+20), ((V(L1_N107) - 0.01)/1.0)) }
Bd1u_107 L1_N107 0 I={ min(((V(L1_N107) + 0.01)/1e+20), ((V(L1_N107) + 0.01)/1.0)) }
Bd1d_108 L1_N108 0 I={ max(((V(L1_N108) - 0.01)/1e+20), ((V(L1_N108) - 0.01)/1.0)) }
Bd1u_108 L1_N108 0 I={ min(((V(L1_N108) + 0.01)/1e+20), ((V(L1_N108) + 0.01)/1.0)) }
Bd1d_109 L1_N109 0 I={ max(((V(L1_N109) - 0.01)/1e+20), ((V(L1_N109) - 0.01)/1.0)) }
Bd1u_109 L1_N109 0 I={ min(((V(L1_N109) + 0.01)/1e+20), ((V(L1_N109) + 0.01)/1.0)) }
Bd1d_110 L1_N110 0 I={ max(((V(L1_N110) - 0.01)/1e+20), ((V(L1_N110) - 0.01)/1.0)) }
Bd1u_110 L1_N110 0 I={ min(((V(L1_N110) + 0.01)/1e+20), ((V(L1_N110) + 0.01)/1.0)) }
Bd1d_111 L1_N111 0 I={ max(((V(L1_N111) - 0.01)/1e+20), ((V(L1_N111) - 0.01)/1.0)) }
Bd1u_111 L1_N111 0 I={ min(((V(L1_N111) + 0.01)/1e+20), ((V(L1_N111) + 0.01)/1.0)) }
Bd1d_112 L1_N112 0 I={ max(((V(L1_N112) - 0.01)/1e+20), ((V(L1_N112) - 0.01)/1.0)) }
Bd1u_112 L1_N112 0 I={ min(((V(L1_N112) + 0.01)/1e+20), ((V(L1_N112) + 0.01)/1.0)) }
Bd1d_113 L1_N113 0 I={ max(((V(L1_N113) - 0.01)/1e+20), ((V(L1_N113) - 0.01)/1.0)) }
Bd1u_113 L1_N113 0 I={ min(((V(L1_N113) + 0.01)/1e+20), ((V(L1_N113) + 0.01)/1.0)) }
Bd1d_114 L1_N114 0 I={ max(((V(L1_N114) - 0.01)/1e+20), ((V(L1_N114) - 0.01)/1.0)) }
Bd1u_114 L1_N114 0 I={ min(((V(L1_N114) + 0.01)/1e+20), ((V(L1_N114) + 0.01)/1.0)) }
Bd1d_115 L1_N115 0 I={ max(((V(L1_N115) - 0.01)/1e+20), ((V(L1_N115) - 0.01)/1.0)) }
Bd1u_115 L1_N115 0 I={ min(((V(L1_N115) + 0.01)/1e+20), ((V(L1_N115) + 0.01)/1.0)) }
Bd1d_116 L1_N116 0 I={ max(((V(L1_N116) - 0.01)/1e+20), ((V(L1_N116) - 0.01)/1.0)) }
Bd1u_116 L1_N116 0 I={ min(((V(L1_N116) + 0.01)/1e+20), ((V(L1_N116) + 0.01)/1.0)) }
Bd1d_117 L1_N117 0 I={ max(((V(L1_N117) - 0.01)/1e+20), ((V(L1_N117) - 0.01)/1.0)) }
Bd1u_117 L1_N117 0 I={ min(((V(L1_N117) + 0.01)/1e+20), ((V(L1_N117) + 0.01)/1.0)) }
Bd1d_118 L1_N118 0 I={ max(((V(L1_N118) - 0.01)/1e+20), ((V(L1_N118) - 0.01)/1.0)) }
Bd1u_118 L1_N118 0 I={ min(((V(L1_N118) + 0.01)/1e+20), ((V(L1_N118) + 0.01)/1.0)) }
Bd1d_119 L1_N119 0 I={ max(((V(L1_N119) - 0.01)/1e+20), ((V(L1_N119) - 0.01)/1.0)) }
Bd1u_119 L1_N119 0 I={ min(((V(L1_N119) + 0.01)/1e+20), ((V(L1_N119) + 0.01)/1.0)) }
Bd1d_120 L1_N120 0 I={ max(((V(L1_N120) - 0.01)/1e+20), ((V(L1_N120) - 0.01)/1.0)) }
Bd1u_120 L1_N120 0 I={ min(((V(L1_N120) + 0.01)/1e+20), ((V(L1_N120) + 0.01)/1.0)) }
Bd1d_121 L1_N121 0 I={ max(((V(L1_N121) - 0.01)/1e+20), ((V(L1_N121) - 0.01)/1.0)) }
Bd1u_121 L1_N121 0 I={ min(((V(L1_N121) + 0.01)/1e+20), ((V(L1_N121) + 0.01)/1.0)) }
Bd1d_122 L1_N122 0 I={ max(((V(L1_N122) - 0.01)/1e+20), ((V(L1_N122) - 0.01)/1.0)) }
Bd1u_122 L1_N122 0 I={ min(((V(L1_N122) + 0.01)/1e+20), ((V(L1_N122) + 0.01)/1.0)) }
Bd1d_123 L1_N123 0 I={ max(((V(L1_N123) - 0.01)/1e+20), ((V(L1_N123) - 0.01)/1.0)) }
Bd1u_123 L1_N123 0 I={ min(((V(L1_N123) + 0.01)/1e+20), ((V(L1_N123) + 0.01)/1.0)) }
Bd1d_124 L1_N124 0 I={ max(((V(L1_N124) - 0.01)/1e+20), ((V(L1_N124) - 0.01)/1.0)) }
Bd1u_124 L1_N124 0 I={ min(((V(L1_N124) + 0.01)/1e+20), ((V(L1_N124) + 0.01)/1.0)) }
Bd1d_125 L1_N125 0 I={ max(((V(L1_N125) - 0.01)/1e+20), ((V(L1_N125) - 0.01)/1.0)) }
Bd1u_125 L1_N125 0 I={ min(((V(L1_N125) + 0.01)/1e+20), ((V(L1_N125) + 0.01)/1.0)) }
Bd1d_126 L1_N126 0 I={ max(((V(L1_N126) - 0.01)/1e+20), ((V(L1_N126) - 0.01)/1.0)) }
Bd1u_126 L1_N126 0 I={ min(((V(L1_N126) + 0.01)/1e+20), ((V(L1_N126) + 0.01)/1.0)) }
Bd1d_127 L1_N127 0 I={ max(((V(L1_N127) - 0.01)/1e+20), ((V(L1_N127) - 0.01)/1.0)) }
Bd1u_127 L1_N127 0 I={ min(((V(L1_N127) + 0.01)/1e+20), ((V(L1_N127) + 0.01)/1.0)) }
Bd1d_128 L1_N128 0 I={ max(((V(L1_N128) - 0.01)/1e+20), ((V(L1_N128) - 0.01)/1.0)) }
Bd1u_128 L1_N128 0 I={ min(((V(L1_N128) + 0.01)/1e+20), ((V(L1_N128) + 0.01)/1.0)) }
Bd1d_129 L1_N129 0 I={ max(((V(L1_N129) - 0.01)/1e+20), ((V(L1_N129) - 0.01)/1.0)) }
Bd1u_129 L1_N129 0 I={ min(((V(L1_N129) + 0.01)/1e+20), ((V(L1_N129) + 0.01)/1.0)) }
Bd1d_130 L1_N130 0 I={ max(((V(L1_N130) - 0.01)/1e+20), ((V(L1_N130) - 0.01)/1.0)) }
Bd1u_130 L1_N130 0 I={ min(((V(L1_N130) + 0.01)/1e+20), ((V(L1_N130) + 0.01)/1.0)) }
Bd1d_131 L1_N131 0 I={ max(((V(L1_N131) - 0.01)/1e+20), ((V(L1_N131) - 0.01)/1.0)) }
Bd1u_131 L1_N131 0 I={ min(((V(L1_N131) + 0.01)/1e+20), ((V(L1_N131) + 0.01)/1.0)) }
Bd1d_132 L1_N132 0 I={ max(((V(L1_N132) - 0.01)/1e+20), ((V(L1_N132) - 0.01)/1.0)) }
Bd1u_132 L1_N132 0 I={ min(((V(L1_N132) + 0.01)/1e+20), ((V(L1_N132) + 0.01)/1.0)) }
Bd1d_133 L1_N133 0 I={ max(((V(L1_N133) - 0.01)/1e+20), ((V(L1_N133) - 0.01)/1.0)) }
Bd1u_133 L1_N133 0 I={ min(((V(L1_N133) + 0.01)/1e+20), ((V(L1_N133) + 0.01)/1.0)) }
Bd1d_134 L1_N134 0 I={ max(((V(L1_N134) - 0.01)/1e+20), ((V(L1_N134) - 0.01)/1.0)) }
Bd1u_134 L1_N134 0 I={ min(((V(L1_N134) + 0.01)/1e+20), ((V(L1_N134) + 0.01)/1.0)) }
Bd1d_135 L1_N135 0 I={ max(((V(L1_N135) - 0.01)/1e+20), ((V(L1_N135) - 0.01)/1.0)) }
Bd1u_135 L1_N135 0 I={ min(((V(L1_N135) + 0.01)/1e+20), ((V(L1_N135) + 0.01)/1.0)) }
Bd1d_136 L1_N136 0 I={ max(((V(L1_N136) - 0.01)/1e+20), ((V(L1_N136) - 0.01)/1.0)) }
Bd1u_136 L1_N136 0 I={ min(((V(L1_N136) + 0.01)/1e+20), ((V(L1_N136) + 0.01)/1.0)) }
Bd1d_137 L1_N137 0 I={ max(((V(L1_N137) - 0.01)/1e+20), ((V(L1_N137) - 0.01)/1.0)) }
Bd1u_137 L1_N137 0 I={ min(((V(L1_N137) + 0.01)/1e+20), ((V(L1_N137) + 0.01)/1.0)) }
Bd1d_138 L1_N138 0 I={ max(((V(L1_N138) - 0.01)/1e+20), ((V(L1_N138) - 0.01)/1.0)) }
Bd1u_138 L1_N138 0 I={ min(((V(L1_N138) + 0.01)/1e+20), ((V(L1_N138) + 0.01)/1.0)) }
Bd1d_139 L1_N139 0 I={ max(((V(L1_N139) - 0.01)/1e+20), ((V(L1_N139) - 0.01)/1.0)) }
Bd1u_139 L1_N139 0 I={ min(((V(L1_N139) + 0.01)/1e+20), ((V(L1_N139) + 0.01)/1.0)) }
Bd1d_140 L1_N140 0 I={ max(((V(L1_N140) - 0.01)/1e+20), ((V(L1_N140) - 0.01)/1.0)) }
Bd1u_140 L1_N140 0 I={ min(((V(L1_N140) + 0.01)/1e+20), ((V(L1_N140) + 0.01)/1.0)) }
Bd1d_141 L1_N141 0 I={ max(((V(L1_N141) - 0.01)/1e+20), ((V(L1_N141) - 0.01)/1.0)) }
Bd1u_141 L1_N141 0 I={ min(((V(L1_N141) + 0.01)/1e+20), ((V(L1_N141) + 0.01)/1.0)) }
Bd1d_142 L1_N142 0 I={ max(((V(L1_N142) - 0.01)/1e+20), ((V(L1_N142) - 0.01)/1.0)) }
Bd1u_142 L1_N142 0 I={ min(((V(L1_N142) + 0.01)/1e+20), ((V(L1_N142) + 0.01)/1.0)) }
Bd1d_143 L1_N143 0 I={ max(((V(L1_N143) - 0.01)/1e+20), ((V(L1_N143) - 0.01)/1.0)) }
Bd1u_143 L1_N143 0 I={ min(((V(L1_N143) + 0.01)/1e+20), ((V(L1_N143) + 0.01)/1.0)) }
Bd1d_144 L1_N144 0 I={ max(((V(L1_N144) - 0.01)/1e+20), ((V(L1_N144) - 0.01)/1.0)) }
Bd1u_144 L1_N144 0 I={ min(((V(L1_N144) + 0.01)/1e+20), ((V(L1_N144) + 0.01)/1.0)) }
Bd1d_145 L1_N145 0 I={ max(((V(L1_N145) - 0.01)/1e+20), ((V(L1_N145) - 0.01)/1.0)) }
Bd1u_145 L1_N145 0 I={ min(((V(L1_N145) + 0.01)/1e+20), ((V(L1_N145) + 0.01)/1.0)) }
Bd1d_146 L1_N146 0 I={ max(((V(L1_N146) - 0.01)/1e+20), ((V(L1_N146) - 0.01)/1.0)) }
Bd1u_146 L1_N146 0 I={ min(((V(L1_N146) + 0.01)/1e+20), ((V(L1_N146) + 0.01)/1.0)) }
Bd1d_147 L1_N147 0 I={ max(((V(L1_N147) - 0.01)/1e+20), ((V(L1_N147) - 0.01)/1.0)) }
Bd1u_147 L1_N147 0 I={ min(((V(L1_N147) + 0.01)/1e+20), ((V(L1_N147) + 0.01)/1.0)) }
Bd1d_148 L1_N148 0 I={ max(((V(L1_N148) - 0.01)/1e+20), ((V(L1_N148) - 0.01)/1.0)) }
Bd1u_148 L1_N148 0 I={ min(((V(L1_N148) + 0.01)/1e+20), ((V(L1_N148) + 0.01)/1.0)) }
Bd1d_149 L1_N149 0 I={ max(((V(L1_N149) - 0.01)/1e+20), ((V(L1_N149) - 0.01)/1.0)) }
Bd1u_149 L1_N149 0 I={ min(((V(L1_N149) + 0.01)/1e+20), ((V(L1_N149) + 0.01)/1.0)) }
Bd1d_150 L1_N150 0 I={ max(((V(L1_N150) - 0.01)/1e+20), ((V(L1_N150) - 0.01)/1.0)) }
Bd1u_150 L1_N150 0 I={ min(((V(L1_N150) + 0.01)/1e+20), ((V(L1_N150) + 0.01)/1.0)) }
Bd1d_151 L1_N151 0 I={ max(((V(L1_N151) - 0.01)/1e+20), ((V(L1_N151) - 0.01)/1.0)) }
Bd1u_151 L1_N151 0 I={ min(((V(L1_N151) + 0.01)/1e+20), ((V(L1_N151) + 0.01)/1.0)) }
Bd1d_152 L1_N152 0 I={ max(((V(L1_N152) - 0.01)/1e+20), ((V(L1_N152) - 0.01)/1.0)) }
Bd1u_152 L1_N152 0 I={ min(((V(L1_N152) + 0.01)/1e+20), ((V(L1_N152) + 0.01)/1.0)) }
Bd1d_153 L1_N153 0 I={ max(((V(L1_N153) - 0.01)/1e+20), ((V(L1_N153) - 0.01)/1.0)) }
Bd1u_153 L1_N153 0 I={ min(((V(L1_N153) + 0.01)/1e+20), ((V(L1_N153) + 0.01)/1.0)) }
Bd1d_154 L1_N154 0 I={ max(((V(L1_N154) - 0.01)/1e+20), ((V(L1_N154) - 0.01)/1.0)) }
Bd1u_154 L1_N154 0 I={ min(((V(L1_N154) + 0.01)/1e+20), ((V(L1_N154) + 0.01)/1.0)) }
Bd1d_155 L1_N155 0 I={ max(((V(L1_N155) - 0.01)/1e+20), ((V(L1_N155) - 0.01)/1.0)) }
Bd1u_155 L1_N155 0 I={ min(((V(L1_N155) + 0.01)/1e+20), ((V(L1_N155) + 0.01)/1.0)) }
Bd1d_156 L1_N156 0 I={ max(((V(L1_N156) - 0.01)/1e+20), ((V(L1_N156) - 0.01)/1.0)) }
Bd1u_156 L1_N156 0 I={ min(((V(L1_N156) + 0.01)/1e+20), ((V(L1_N156) + 0.01)/1.0)) }
Bd1d_157 L1_N157 0 I={ max(((V(L1_N157) - 0.01)/1e+20), ((V(L1_N157) - 0.01)/1.0)) }
Bd1u_157 L1_N157 0 I={ min(((V(L1_N157) + 0.01)/1e+20), ((V(L1_N157) + 0.01)/1.0)) }
Bd1d_158 L1_N158 0 I={ max(((V(L1_N158) - 0.01)/1e+20), ((V(L1_N158) - 0.01)/1.0)) }
Bd1u_158 L1_N158 0 I={ min(((V(L1_N158) + 0.01)/1e+20), ((V(L1_N158) + 0.01)/1.0)) }
Bd1d_159 L1_N159 0 I={ max(((V(L1_N159) - 0.01)/1e+20), ((V(L1_N159) - 0.01)/1.0)) }
Bd1u_159 L1_N159 0 I={ min(((V(L1_N159) + 0.01)/1e+20), ((V(L1_N159) + 0.01)/1.0)) }
Bd1d_160 L1_N160 0 I={ max(((V(L1_N160) - 0.01)/1e+20), ((V(L1_N160) - 0.01)/1.0)) }
Bd1u_160 L1_N160 0 I={ min(((V(L1_N160) + 0.01)/1e+20), ((V(L1_N160) + 0.01)/1.0)) }
Bd1d_161 L1_N161 0 I={ max(((V(L1_N161) - 0.01)/1e+20), ((V(L1_N161) - 0.01)/1.0)) }
Bd1u_161 L1_N161 0 I={ min(((V(L1_N161) + 0.01)/1e+20), ((V(L1_N161) + 0.01)/1.0)) }
Bd1d_162 L1_N162 0 I={ max(((V(L1_N162) - 0.01)/1e+20), ((V(L1_N162) - 0.01)/1.0)) }
Bd1u_162 L1_N162 0 I={ min(((V(L1_N162) + 0.01)/1e+20), ((V(L1_N162) + 0.01)/1.0)) }
Bd1d_163 L1_N163 0 I={ max(((V(L1_N163) - 0.01)/1e+20), ((V(L1_N163) - 0.01)/1.0)) }
Bd1u_163 L1_N163 0 I={ min(((V(L1_N163) + 0.01)/1e+20), ((V(L1_N163) + 0.01)/1.0)) }
Bd1d_164 L1_N164 0 I={ max(((V(L1_N164) - 0.01)/1e+20), ((V(L1_N164) - 0.01)/1.0)) }
Bd1u_164 L1_N164 0 I={ min(((V(L1_N164) + 0.01)/1e+20), ((V(L1_N164) + 0.01)/1.0)) }
Bd1d_165 L1_N165 0 I={ max(((V(L1_N165) - 0.01)/1e+20), ((V(L1_N165) - 0.01)/1.0)) }
Bd1u_165 L1_N165 0 I={ min(((V(L1_N165) + 0.01)/1e+20), ((V(L1_N165) + 0.01)/1.0)) }
Bd1d_166 L1_N166 0 I={ max(((V(L1_N166) - 0.01)/1e+20), ((V(L1_N166) - 0.01)/1.0)) }
Bd1u_166 L1_N166 0 I={ min(((V(L1_N166) + 0.01)/1e+20), ((V(L1_N166) + 0.01)/1.0)) }
Bd1d_167 L1_N167 0 I={ max(((V(L1_N167) - 0.01)/1e+20), ((V(L1_N167) - 0.01)/1.0)) }
Bd1u_167 L1_N167 0 I={ min(((V(L1_N167) + 0.01)/1e+20), ((V(L1_N167) + 0.01)/1.0)) }
Bd1d_168 L1_N168 0 I={ max(((V(L1_N168) - 0.01)/1e+20), ((V(L1_N168) - 0.01)/1.0)) }
Bd1u_168 L1_N168 0 I={ min(((V(L1_N168) + 0.01)/1e+20), ((V(L1_N168) + 0.01)/1.0)) }
Bd1d_169 L1_N169 0 I={ max(((V(L1_N169) - 0.01)/1e+20), ((V(L1_N169) - 0.01)/1.0)) }
Bd1u_169 L1_N169 0 I={ min(((V(L1_N169) + 0.01)/1e+20), ((V(L1_N169) + 0.01)/1.0)) }
Bd1d_170 L1_N170 0 I={ max(((V(L1_N170) - 0.01)/1e+20), ((V(L1_N170) - 0.01)/1.0)) }
Bd1u_170 L1_N170 0 I={ min(((V(L1_N170) + 0.01)/1e+20), ((V(L1_N170) + 0.01)/1.0)) }
Bd1d_171 L1_N171 0 I={ max(((V(L1_N171) - 0.01)/1e+20), ((V(L1_N171) - 0.01)/1.0)) }
Bd1u_171 L1_N171 0 I={ min(((V(L1_N171) + 0.01)/1e+20), ((V(L1_N171) + 0.01)/1.0)) }
Bd1d_172 L1_N172 0 I={ max(((V(L1_N172) - 0.01)/1e+20), ((V(L1_N172) - 0.01)/1.0)) }
Bd1u_172 L1_N172 0 I={ min(((V(L1_N172) + 0.01)/1e+20), ((V(L1_N172) + 0.01)/1.0)) }
Bd1d_173 L1_N173 0 I={ max(((V(L1_N173) - 0.01)/1e+20), ((V(L1_N173) - 0.01)/1.0)) }
Bd1u_173 L1_N173 0 I={ min(((V(L1_N173) + 0.01)/1e+20), ((V(L1_N173) + 0.01)/1.0)) }
Bd1d_174 L1_N174 0 I={ max(((V(L1_N174) - 0.01)/1e+20), ((V(L1_N174) - 0.01)/1.0)) }
Bd1u_174 L1_N174 0 I={ min(((V(L1_N174) + 0.01)/1e+20), ((V(L1_N174) + 0.01)/1.0)) }
Bd1d_175 L1_N175 0 I={ max(((V(L1_N175) - 0.01)/1e+20), ((V(L1_N175) - 0.01)/1.0)) }
Bd1u_175 L1_N175 0 I={ min(((V(L1_N175) + 0.01)/1e+20), ((V(L1_N175) + 0.01)/1.0)) }
Bd1d_176 L1_N176 0 I={ max(((V(L1_N176) - 0.01)/1e+20), ((V(L1_N176) - 0.01)/1.0)) }
Bd1u_176 L1_N176 0 I={ min(((V(L1_N176) + 0.01)/1e+20), ((V(L1_N176) + 0.01)/1.0)) }
Bd1d_177 L1_N177 0 I={ max(((V(L1_N177) - 0.01)/1e+20), ((V(L1_N177) - 0.01)/1.0)) }
Bd1u_177 L1_N177 0 I={ min(((V(L1_N177) + 0.01)/1e+20), ((V(L1_N177) + 0.01)/1.0)) }
Bd1d_178 L1_N178 0 I={ max(((V(L1_N178) - 0.01)/1e+20), ((V(L1_N178) - 0.01)/1.0)) }
Bd1u_178 L1_N178 0 I={ min(((V(L1_N178) + 0.01)/1e+20), ((V(L1_N178) + 0.01)/1.0)) }
Bd1d_179 L1_N179 0 I={ max(((V(L1_N179) - 0.01)/1e+20), ((V(L1_N179) - 0.01)/1.0)) }
Bd1u_179 L1_N179 0 I={ min(((V(L1_N179) + 0.01)/1e+20), ((V(L1_N179) + 0.01)/1.0)) }
Bd1d_180 L1_N180 0 I={ max(((V(L1_N180) - 0.01)/1e+20), ((V(L1_N180) - 0.01)/1.0)) }
Bd1u_180 L1_N180 0 I={ min(((V(L1_N180) + 0.01)/1e+20), ((V(L1_N180) + 0.01)/1.0)) }
Bd1d_181 L1_N181 0 I={ max(((V(L1_N181) - 0.01)/1e+20), ((V(L1_N181) - 0.01)/1.0)) }
Bd1u_181 L1_N181 0 I={ min(((V(L1_N181) + 0.01)/1e+20), ((V(L1_N181) + 0.01)/1.0)) }
Bd1d_182 L1_N182 0 I={ max(((V(L1_N182) - 0.01)/1e+20), ((V(L1_N182) - 0.01)/1.0)) }
Bd1u_182 L1_N182 0 I={ min(((V(L1_N182) + 0.01)/1e+20), ((V(L1_N182) + 0.01)/1.0)) }
Bd1d_183 L1_N183 0 I={ max(((V(L1_N183) - 0.01)/1e+20), ((V(L1_N183) - 0.01)/1.0)) }
Bd1u_183 L1_N183 0 I={ min(((V(L1_N183) + 0.01)/1e+20), ((V(L1_N183) + 0.01)/1.0)) }
Bd1d_184 L1_N184 0 I={ max(((V(L1_N184) - 0.01)/1e+20), ((V(L1_N184) - 0.01)/1.0)) }
Bd1u_184 L1_N184 0 I={ min(((V(L1_N184) + 0.01)/1e+20), ((V(L1_N184) + 0.01)/1.0)) }
Bd1d_185 L1_N185 0 I={ max(((V(L1_N185) - 0.01)/1e+20), ((V(L1_N185) - 0.01)/1.0)) }
Bd1u_185 L1_N185 0 I={ min(((V(L1_N185) + 0.01)/1e+20), ((V(L1_N185) + 0.01)/1.0)) }
Bd1d_186 L1_N186 0 I={ max(((V(L1_N186) - 0.01)/1e+20), ((V(L1_N186) - 0.01)/1.0)) }
Bd1u_186 L1_N186 0 I={ min(((V(L1_N186) + 0.01)/1e+20), ((V(L1_N186) + 0.01)/1.0)) }
Bd1d_187 L1_N187 0 I={ max(((V(L1_N187) - 0.01)/1e+20), ((V(L1_N187) - 0.01)/1.0)) }
Bd1u_187 L1_N187 0 I={ min(((V(L1_N187) + 0.01)/1e+20), ((V(L1_N187) + 0.01)/1.0)) }
Bd1d_188 L1_N188 0 I={ max(((V(L1_N188) - 0.01)/1e+20), ((V(L1_N188) - 0.01)/1.0)) }
Bd1u_188 L1_N188 0 I={ min(((V(L1_N188) + 0.01)/1e+20), ((V(L1_N188) + 0.01)/1.0)) }
Bd1d_189 L1_N189 0 I={ max(((V(L1_N189) - 0.01)/1e+20), ((V(L1_N189) - 0.01)/1.0)) }
Bd1u_189 L1_N189 0 I={ min(((V(L1_N189) + 0.01)/1e+20), ((V(L1_N189) + 0.01)/1.0)) }
Bd1d_190 L1_N190 0 I={ max(((V(L1_N190) - 0.01)/1e+20), ((V(L1_N190) - 0.01)/1.0)) }
Bd1u_190 L1_N190 0 I={ min(((V(L1_N190) + 0.01)/1e+20), ((V(L1_N190) + 0.01)/1.0)) }
Bd1d_191 L1_N191 0 I={ max(((V(L1_N191) - 0.01)/1e+20), ((V(L1_N191) - 0.01)/1.0)) }
Bd1u_191 L1_N191 0 I={ min(((V(L1_N191) + 0.01)/1e+20), ((V(L1_N191) + 0.01)/1.0)) }
Bd1d_192 L1_N192 0 I={ max(((V(L1_N192) - 0.01)/1e+20), ((V(L1_N192) - 0.01)/1.0)) }
Bd1u_192 L1_N192 0 I={ min(((V(L1_N192) + 0.01)/1e+20), ((V(L1_N192) + 0.01)/1.0)) }
Bd1d_193 L1_N193 0 I={ max(((V(L1_N193) - 0.01)/1e+20), ((V(L1_N193) - 0.01)/1.0)) }
Bd1u_193 L1_N193 0 I={ min(((V(L1_N193) + 0.01)/1e+20), ((V(L1_N193) + 0.01)/1.0)) }
Bd1d_194 L1_N194 0 I={ max(((V(L1_N194) - 0.01)/1e+20), ((V(L1_N194) - 0.01)/1.0)) }
Bd1u_194 L1_N194 0 I={ min(((V(L1_N194) + 0.01)/1e+20), ((V(L1_N194) + 0.01)/1.0)) }
Bd1d_195 L1_N195 0 I={ max(((V(L1_N195) - 0.01)/1e+20), ((V(L1_N195) - 0.01)/1.0)) }
Bd1u_195 L1_N195 0 I={ min(((V(L1_N195) + 0.01)/1e+20), ((V(L1_N195) + 0.01)/1.0)) }
Bd1d_196 L1_N196 0 I={ max(((V(L1_N196) - 0.01)/1e+20), ((V(L1_N196) - 0.01)/1.0)) }
Bd1u_196 L1_N196 0 I={ min(((V(L1_N196) + 0.01)/1e+20), ((V(L1_N196) + 0.01)/1.0)) }
Bd1d_197 L1_N197 0 I={ max(((V(L1_N197) - 0.01)/1e+20), ((V(L1_N197) - 0.01)/1.0)) }
Bd1u_197 L1_N197 0 I={ min(((V(L1_N197) + 0.01)/1e+20), ((V(L1_N197) + 0.01)/1.0)) }
Bd1d_198 L1_N198 0 I={ max(((V(L1_N198) - 0.01)/1e+20), ((V(L1_N198) - 0.01)/1.0)) }
Bd1u_198 L1_N198 0 I={ min(((V(L1_N198) + 0.01)/1e+20), ((V(L1_N198) + 0.01)/1.0)) }
Bd1d_199 L1_N199 0 I={ max(((V(L1_N199) - 0.01)/1e+20), ((V(L1_N199) - 0.01)/1.0)) }
Bd1u_199 L1_N199 0 I={ min(((V(L1_N199) + 0.01)/1e+20), ((V(L1_N199) + 0.01)/1.0)) }
Bd1d_200 L1_N200 0 I={ max(((V(L1_N200) - 0.01)/1e+20), ((V(L1_N200) - 0.01)/1.0)) }
Bd1u_200 L1_N200 0 I={ min(((V(L1_N200) + 0.01)/1e+20), ((V(L1_N200) + 0.01)/1.0)) }
Bd1d_201 L1_N201 0 I={ max(((V(L1_N201) - 0.01)/1e+20), ((V(L1_N201) - 0.01)/1.0)) }
Bd1u_201 L1_N201 0 I={ min(((V(L1_N201) + 0.01)/1e+20), ((V(L1_N201) + 0.01)/1.0)) }
Bd1d_202 L1_N202 0 I={ max(((V(L1_N202) - 0.01)/1e+20), ((V(L1_N202) - 0.01)/1.0)) }
Bd1u_202 L1_N202 0 I={ min(((V(L1_N202) + 0.01)/1e+20), ((V(L1_N202) + 0.01)/1.0)) }
Bd1d_203 L1_N203 0 I={ max(((V(L1_N203) - 0.01)/1e+20), ((V(L1_N203) - 0.01)/1.0)) }
Bd1u_203 L1_N203 0 I={ min(((V(L1_N203) + 0.01)/1e+20), ((V(L1_N203) + 0.01)/1.0)) }
Bd1d_204 L1_N204 0 I={ max(((V(L1_N204) - 0.01)/1e+20), ((V(L1_N204) - 0.01)/1.0)) }
Bd1u_204 L1_N204 0 I={ min(((V(L1_N204) + 0.01)/1e+20), ((V(L1_N204) + 0.01)/1.0)) }
Bd1d_205 L1_N205 0 I={ max(((V(L1_N205) - 0.01)/1e+20), ((V(L1_N205) - 0.01)/1.0)) }
Bd1u_205 L1_N205 0 I={ min(((V(L1_N205) + 0.01)/1e+20), ((V(L1_N205) + 0.01)/1.0)) }
Bd1d_206 L1_N206 0 I={ max(((V(L1_N206) - 0.01)/1e+20), ((V(L1_N206) - 0.01)/1.0)) }
Bd1u_206 L1_N206 0 I={ min(((V(L1_N206) + 0.01)/1e+20), ((V(L1_N206) + 0.01)/1.0)) }
Bd1d_207 L1_N207 0 I={ max(((V(L1_N207) - 0.01)/1e+20), ((V(L1_N207) - 0.01)/1.0)) }
Bd1u_207 L1_N207 0 I={ min(((V(L1_N207) + 0.01)/1e+20), ((V(L1_N207) + 0.01)/1.0)) }
Bd1d_208 L1_N208 0 I={ max(((V(L1_N208) - 0.01)/1e+20), ((V(L1_N208) - 0.01)/1.0)) }
Bd1u_208 L1_N208 0 I={ min(((V(L1_N208) + 0.01)/1e+20), ((V(L1_N208) + 0.01)/1.0)) }
Bd1d_209 L1_N209 0 I={ max(((V(L1_N209) - 0.01)/1e+20), ((V(L1_N209) - 0.01)/1.0)) }
Bd1u_209 L1_N209 0 I={ min(((V(L1_N209) + 0.01)/1e+20), ((V(L1_N209) + 0.01)/1.0)) }
Bd1d_210 L1_N210 0 I={ max(((V(L1_N210) - 0.01)/1e+20), ((V(L1_N210) - 0.01)/1.0)) }
Bd1u_210 L1_N210 0 I={ min(((V(L1_N210) + 0.01)/1e+20), ((V(L1_N210) + 0.01)/1.0)) }
Bd1d_211 L1_N211 0 I={ max(((V(L1_N211) - 0.01)/1e+20), ((V(L1_N211) - 0.01)/1.0)) }
Bd1u_211 L1_N211 0 I={ min(((V(L1_N211) + 0.01)/1e+20), ((V(L1_N211) + 0.01)/1.0)) }
Bd1d_212 L1_N212 0 I={ max(((V(L1_N212) - 0.01)/1e+20), ((V(L1_N212) - 0.01)/1.0)) }
Bd1u_212 L1_N212 0 I={ min(((V(L1_N212) + 0.01)/1e+20), ((V(L1_N212) + 0.01)/1.0)) }
Bd1d_213 L1_N213 0 I={ max(((V(L1_N213) - 0.01)/1e+20), ((V(L1_N213) - 0.01)/1.0)) }
Bd1u_213 L1_N213 0 I={ min(((V(L1_N213) + 0.01)/1e+20), ((V(L1_N213) + 0.01)/1.0)) }
Bd1d_214 L1_N214 0 I={ max(((V(L1_N214) - 0.01)/1e+20), ((V(L1_N214) - 0.01)/1.0)) }
Bd1u_214 L1_N214 0 I={ min(((V(L1_N214) + 0.01)/1e+20), ((V(L1_N214) + 0.01)/1.0)) }
Bd1d_215 L1_N215 0 I={ max(((V(L1_N215) - 0.01)/1e+20), ((V(L1_N215) - 0.01)/1.0)) }
Bd1u_215 L1_N215 0 I={ min(((V(L1_N215) + 0.01)/1e+20), ((V(L1_N215) + 0.01)/1.0)) }
Bd1d_216 L1_N216 0 I={ max(((V(L1_N216) - 0.01)/1e+20), ((V(L1_N216) - 0.01)/1.0)) }
Bd1u_216 L1_N216 0 I={ min(((V(L1_N216) + 0.01)/1e+20), ((V(L1_N216) + 0.01)/1.0)) }
Bd1d_217 L1_N217 0 I={ max(((V(L1_N217) - 0.01)/1e+20), ((V(L1_N217) - 0.01)/1.0)) }
Bd1u_217 L1_N217 0 I={ min(((V(L1_N217) + 0.01)/1e+20), ((V(L1_N217) + 0.01)/1.0)) }
Bd1d_218 L1_N218 0 I={ max(((V(L1_N218) - 0.01)/1e+20), ((V(L1_N218) - 0.01)/1.0)) }
Bd1u_218 L1_N218 0 I={ min(((V(L1_N218) + 0.01)/1e+20), ((V(L1_N218) + 0.01)/1.0)) }
Bd1d_219 L1_N219 0 I={ max(((V(L1_N219) - 0.01)/1e+20), ((V(L1_N219) - 0.01)/1.0)) }
Bd1u_219 L1_N219 0 I={ min(((V(L1_N219) + 0.01)/1e+20), ((V(L1_N219) + 0.01)/1.0)) }
Bd1d_220 L1_N220 0 I={ max(((V(L1_N220) - 0.01)/1e+20), ((V(L1_N220) - 0.01)/1.0)) }
Bd1u_220 L1_N220 0 I={ min(((V(L1_N220) + 0.01)/1e+20), ((V(L1_N220) + 0.01)/1.0)) }
Bd1d_221 L1_N221 0 I={ max(((V(L1_N221) - 0.01)/1e+20), ((V(L1_N221) - 0.01)/1.0)) }
Bd1u_221 L1_N221 0 I={ min(((V(L1_N221) + 0.01)/1e+20), ((V(L1_N221) + 0.01)/1.0)) }
Bd1d_222 L1_N222 0 I={ max(((V(L1_N222) - 0.01)/1e+20), ((V(L1_N222) - 0.01)/1.0)) }
Bd1u_222 L1_N222 0 I={ min(((V(L1_N222) + 0.01)/1e+20), ((V(L1_N222) + 0.01)/1.0)) }
Bd1d_223 L1_N223 0 I={ max(((V(L1_N223) - 0.01)/1e+20), ((V(L1_N223) - 0.01)/1.0)) }
Bd1u_223 L1_N223 0 I={ min(((V(L1_N223) + 0.01)/1e+20), ((V(L1_N223) + 0.01)/1.0)) }
Bd1d_224 L1_N224 0 I={ max(((V(L1_N224) - 0.01)/1e+20), ((V(L1_N224) - 0.01)/1.0)) }
Bd1u_224 L1_N224 0 I={ min(((V(L1_N224) + 0.01)/1e+20), ((V(L1_N224) + 0.01)/1.0)) }
Bd1d_225 L1_N225 0 I={ max(((V(L1_N225) - 0.01)/1e+20), ((V(L1_N225) - 0.01)/1.0)) }
Bd1u_225 L1_N225 0 I={ min(((V(L1_N225) + 0.01)/1e+20), ((V(L1_N225) + 0.01)/1.0)) }
Bd1d_226 L1_N226 0 I={ max(((V(L1_N226) - 0.01)/1e+20), ((V(L1_N226) - 0.01)/1.0)) }
Bd1u_226 L1_N226 0 I={ min(((V(L1_N226) + 0.01)/1e+20), ((V(L1_N226) + 0.01)/1.0)) }
Bd1d_227 L1_N227 0 I={ max(((V(L1_N227) - 0.01)/1e+20), ((V(L1_N227) - 0.01)/1.0)) }
Bd1u_227 L1_N227 0 I={ min(((V(L1_N227) + 0.01)/1e+20), ((V(L1_N227) + 0.01)/1.0)) }
Bd1d_228 L1_N228 0 I={ max(((V(L1_N228) - 0.01)/1e+20), ((V(L1_N228) - 0.01)/1.0)) }
Bd1u_228 L1_N228 0 I={ min(((V(L1_N228) + 0.01)/1e+20), ((V(L1_N228) + 0.01)/1.0)) }
Bd1d_229 L1_N229 0 I={ max(((V(L1_N229) - 0.01)/1e+20), ((V(L1_N229) - 0.01)/1.0)) }
Bd1u_229 L1_N229 0 I={ min(((V(L1_N229) + 0.01)/1e+20), ((V(L1_N229) + 0.01)/1.0)) }
Bd1d_230 L1_N230 0 I={ max(((V(L1_N230) - 0.01)/1e+20), ((V(L1_N230) - 0.01)/1.0)) }
Bd1u_230 L1_N230 0 I={ min(((V(L1_N230) + 0.01)/1e+20), ((V(L1_N230) + 0.01)/1.0)) }
Bd1d_231 L1_N231 0 I={ max(((V(L1_N231) - 0.01)/1e+20), ((V(L1_N231) - 0.01)/1.0)) }
Bd1u_231 L1_N231 0 I={ min(((V(L1_N231) + 0.01)/1e+20), ((V(L1_N231) + 0.01)/1.0)) }
Bd1d_232 L1_N232 0 I={ max(((V(L1_N232) - 0.01)/1e+20), ((V(L1_N232) - 0.01)/1.0)) }
Bd1u_232 L1_N232 0 I={ min(((V(L1_N232) + 0.01)/1e+20), ((V(L1_N232) + 0.01)/1.0)) }
Bd1d_233 L1_N233 0 I={ max(((V(L1_N233) - 0.01)/1e+20), ((V(L1_N233) - 0.01)/1.0)) }
Bd1u_233 L1_N233 0 I={ min(((V(L1_N233) + 0.01)/1e+20), ((V(L1_N233) + 0.01)/1.0)) }
Bd1d_234 L1_N234 0 I={ max(((V(L1_N234) - 0.01)/1e+20), ((V(L1_N234) - 0.01)/1.0)) }
Bd1u_234 L1_N234 0 I={ min(((V(L1_N234) + 0.01)/1e+20), ((V(L1_N234) + 0.01)/1.0)) }
Bd1d_235 L1_N235 0 I={ max(((V(L1_N235) - 0.01)/1e+20), ((V(L1_N235) - 0.01)/1.0)) }
Bd1u_235 L1_N235 0 I={ min(((V(L1_N235) + 0.01)/1e+20), ((V(L1_N235) + 0.01)/1.0)) }
Bd1d_236 L1_N236 0 I={ max(((V(L1_N236) - 0.01)/1e+20), ((V(L1_N236) - 0.01)/1.0)) }
Bd1u_236 L1_N236 0 I={ min(((V(L1_N236) + 0.01)/1e+20), ((V(L1_N236) + 0.01)/1.0)) }
Bd1d_237 L1_N237 0 I={ max(((V(L1_N237) - 0.01)/1e+20), ((V(L1_N237) - 0.01)/1.0)) }
Bd1u_237 L1_N237 0 I={ min(((V(L1_N237) + 0.01)/1e+20), ((V(L1_N237) + 0.01)/1.0)) }
Bd1d_238 L1_N238 0 I={ max(((V(L1_N238) - 0.01)/1e+20), ((V(L1_N238) - 0.01)/1.0)) }
Bd1u_238 L1_N238 0 I={ min(((V(L1_N238) + 0.01)/1e+20), ((V(L1_N238) + 0.01)/1.0)) }
Bd1d_239 L1_N239 0 I={ max(((V(L1_N239) - 0.01)/1e+20), ((V(L1_N239) - 0.01)/1.0)) }
Bd1u_239 L1_N239 0 I={ min(((V(L1_N239) + 0.01)/1e+20), ((V(L1_N239) + 0.01)/1.0)) }
Bd1d_240 L1_N240 0 I={ max(((V(L1_N240) - 0.01)/1e+20), ((V(L1_N240) - 0.01)/1.0)) }
Bd1u_240 L1_N240 0 I={ min(((V(L1_N240) + 0.01)/1e+20), ((V(L1_N240) + 0.01)/1.0)) }
Bd1d_241 L1_N241 0 I={ max(((V(L1_N241) - 0.01)/1e+20), ((V(L1_N241) - 0.01)/1.0)) }
Bd1u_241 L1_N241 0 I={ min(((V(L1_N241) + 0.01)/1e+20), ((V(L1_N241) + 0.01)/1.0)) }
Bd1d_242 L1_N242 0 I={ max(((V(L1_N242) - 0.01)/1e+20), ((V(L1_N242) - 0.01)/1.0)) }
Bd1u_242 L1_N242 0 I={ min(((V(L1_N242) + 0.01)/1e+20), ((V(L1_N242) + 0.01)/1.0)) }
Bd1d_243 L1_N243 0 I={ max(((V(L1_N243) - 0.01)/1e+20), ((V(L1_N243) - 0.01)/1.0)) }
Bd1u_243 L1_N243 0 I={ min(((V(L1_N243) + 0.01)/1e+20), ((V(L1_N243) + 0.01)/1.0)) }
Bd1d_244 L1_N244 0 I={ max(((V(L1_N244) - 0.01)/1e+20), ((V(L1_N244) - 0.01)/1.0)) }
Bd1u_244 L1_N244 0 I={ min(((V(L1_N244) + 0.01)/1e+20), ((V(L1_N244) + 0.01)/1.0)) }
Bd1d_245 L1_N245 0 I={ max(((V(L1_N245) - 0.01)/1e+20), ((V(L1_N245) - 0.01)/1.0)) }
Bd1u_245 L1_N245 0 I={ min(((V(L1_N245) + 0.01)/1e+20), ((V(L1_N245) + 0.01)/1.0)) }
Bd1d_246 L1_N246 0 I={ max(((V(L1_N246) - 0.01)/1e+20), ((V(L1_N246) - 0.01)/1.0)) }
Bd1u_246 L1_N246 0 I={ min(((V(L1_N246) + 0.01)/1e+20), ((V(L1_N246) + 0.01)/1.0)) }
Bd1d_247 L1_N247 0 I={ max(((V(L1_N247) - 0.01)/1e+20), ((V(L1_N247) - 0.01)/1.0)) }
Bd1u_247 L1_N247 0 I={ min(((V(L1_N247) + 0.01)/1e+20), ((V(L1_N247) + 0.01)/1.0)) }
Bd1d_248 L1_N248 0 I={ max(((V(L1_N248) - 0.01)/1e+20), ((V(L1_N248) - 0.01)/1.0)) }
Bd1u_248 L1_N248 0 I={ min(((V(L1_N248) + 0.01)/1e+20), ((V(L1_N248) + 0.01)/1.0)) }
Bd1d_249 L1_N249 0 I={ max(((V(L1_N249) - 0.01)/1e+20), ((V(L1_N249) - 0.01)/1.0)) }
Bd1u_249 L1_N249 0 I={ min(((V(L1_N249) + 0.01)/1e+20), ((V(L1_N249) + 0.01)/1.0)) }
Bd1d_250 L1_N250 0 I={ max(((V(L1_N250) - 0.01)/1e+20), ((V(L1_N250) - 0.01)/1.0)) }
Bd1u_250 L1_N250 0 I={ min(((V(L1_N250) + 0.01)/1e+20), ((V(L1_N250) + 0.01)/1.0)) }
Bd1d_251 L1_N251 0 I={ max(((V(L1_N251) - 0.01)/1e+20), ((V(L1_N251) - 0.01)/1.0)) }
Bd1u_251 L1_N251 0 I={ min(((V(L1_N251) + 0.01)/1e+20), ((V(L1_N251) + 0.01)/1.0)) }
Bd1d_252 L1_N252 0 I={ max(((V(L1_N252) - 0.01)/1e+20), ((V(L1_N252) - 0.01)/1.0)) }
Bd1u_252 L1_N252 0 I={ min(((V(L1_N252) + 0.01)/1e+20), ((V(L1_N252) + 0.01)/1.0)) }
Bd1d_253 L1_N253 0 I={ max(((V(L1_N253) - 0.01)/1e+20), ((V(L1_N253) - 0.01)/1.0)) }
Bd1u_253 L1_N253 0 I={ min(((V(L1_N253) + 0.01)/1e+20), ((V(L1_N253) + 0.01)/1.0)) }
Bd1d_254 L1_N254 0 I={ max(((V(L1_N254) - 0.01)/1e+20), ((V(L1_N254) - 0.01)/1.0)) }
Bd1u_254 L1_N254 0 I={ min(((V(L1_N254) + 0.01)/1e+20), ((V(L1_N254) + 0.01)/1.0)) }
Bd1d_255 L1_N255 0 I={ max(((V(L1_N255) - 0.01)/1e+20), ((V(L1_N255) - 0.01)/1.0)) }
Bd1u_255 L1_N255 0 I={ min(((V(L1_N255) + 0.01)/1e+20), ((V(L1_N255) + 0.01)/1.0)) }
Bd1d_256 L1_N256 0 I={ max(((V(L1_N256) - 0.01)/1e+20), ((V(L1_N256) - 0.01)/1.0)) }
Bd1u_256 L1_N256 0 I={ min(((V(L1_N256) + 0.01)/1e+20), ((V(L1_N256) + 0.01)/1.0)) }
Bd1d_257 L1_N257 0 I={ max(((V(L1_N257) - 0.01)/1e+20), ((V(L1_N257) - 0.01)/1.0)) }
Bd1u_257 L1_N257 0 I={ min(((V(L1_N257) + 0.01)/1e+20), ((V(L1_N257) + 0.01)/1.0)) }
Bd1d_258 L1_N258 0 I={ max(((V(L1_N258) - 0.01)/1e+20), ((V(L1_N258) - 0.01)/1.0)) }
Bd1u_258 L1_N258 0 I={ min(((V(L1_N258) + 0.01)/1e+20), ((V(L1_N258) + 0.01)/1.0)) }
Bd1d_259 L1_N259 0 I={ max(((V(L1_N259) - 0.01)/1e+20), ((V(L1_N259) - 0.01)/1.0)) }
Bd1u_259 L1_N259 0 I={ min(((V(L1_N259) + 0.01)/1e+20), ((V(L1_N259) + 0.01)/1.0)) }
Bd1d_260 L1_N260 0 I={ max(((V(L1_N260) - 0.01)/1e+20), ((V(L1_N260) - 0.01)/1.0)) }
Bd1u_260 L1_N260 0 I={ min(((V(L1_N260) + 0.01)/1e+20), ((V(L1_N260) + 0.01)/1.0)) }
Bd1d_261 L1_N261 0 I={ max(((V(L1_N261) - 0.01)/1e+20), ((V(L1_N261) - 0.01)/1.0)) }
Bd1u_261 L1_N261 0 I={ min(((V(L1_N261) + 0.01)/1e+20), ((V(L1_N261) + 0.01)/1.0)) }
Bd1d_262 L1_N262 0 I={ max(((V(L1_N262) - 0.01)/1e+20), ((V(L1_N262) - 0.01)/1.0)) }
Bd1u_262 L1_N262 0 I={ min(((V(L1_N262) + 0.01)/1e+20), ((V(L1_N262) + 0.01)/1.0)) }
Bd1d_263 L1_N263 0 I={ max(((V(L1_N263) - 0.01)/1e+20), ((V(L1_N263) - 0.01)/1.0)) }
Bd1u_263 L1_N263 0 I={ min(((V(L1_N263) + 0.01)/1e+20), ((V(L1_N263) + 0.01)/1.0)) }
Bd1d_264 L1_N264 0 I={ max(((V(L1_N264) - 0.01)/1e+20), ((V(L1_N264) - 0.01)/1.0)) }
Bd1u_264 L1_N264 0 I={ min(((V(L1_N264) + 0.01)/1e+20), ((V(L1_N264) + 0.01)/1.0)) }
Bd1d_265 L1_N265 0 I={ max(((V(L1_N265) - 0.01)/1e+20), ((V(L1_N265) - 0.01)/1.0)) }
Bd1u_265 L1_N265 0 I={ min(((V(L1_N265) + 0.01)/1e+20), ((V(L1_N265) + 0.01)/1.0)) }
Bd1d_266 L1_N266 0 I={ max(((V(L1_N266) - 0.01)/1e+20), ((V(L1_N266) - 0.01)/1.0)) }
Bd1u_266 L1_N266 0 I={ min(((V(L1_N266) + 0.01)/1e+20), ((V(L1_N266) + 0.01)/1.0)) }
Bd1d_267 L1_N267 0 I={ max(((V(L1_N267) - 0.01)/1e+20), ((V(L1_N267) - 0.01)/1.0)) }
Bd1u_267 L1_N267 0 I={ min(((V(L1_N267) + 0.01)/1e+20), ((V(L1_N267) + 0.01)/1.0)) }
Bd1d_268 L1_N268 0 I={ max(((V(L1_N268) - 0.01)/1e+20), ((V(L1_N268) - 0.01)/1.0)) }
Bd1u_268 L1_N268 0 I={ min(((V(L1_N268) + 0.01)/1e+20), ((V(L1_N268) + 0.01)/1.0)) }
Bd1d_269 L1_N269 0 I={ max(((V(L1_N269) - 0.01)/1e+20), ((V(L1_N269) - 0.01)/1.0)) }
Bd1u_269 L1_N269 0 I={ min(((V(L1_N269) + 0.01)/1e+20), ((V(L1_N269) + 0.01)/1.0)) }
Bd1d_270 L1_N270 0 I={ max(((V(L1_N270) - 0.01)/1e+20), ((V(L1_N270) - 0.01)/1.0)) }
Bd1u_270 L1_N270 0 I={ min(((V(L1_N270) + 0.01)/1e+20), ((V(L1_N270) + 0.01)/1.0)) }
Bd1d_271 L1_N271 0 I={ max(((V(L1_N271) - 0.01)/1e+20), ((V(L1_N271) - 0.01)/1.0)) }
Bd1u_271 L1_N271 0 I={ min(((V(L1_N271) + 0.01)/1e+20), ((V(L1_N271) + 0.01)/1.0)) }
Bd1d_272 L1_N272 0 I={ max(((V(L1_N272) - 0.01)/1e+20), ((V(L1_N272) - 0.01)/1.0)) }
Bd1u_272 L1_N272 0 I={ min(((V(L1_N272) + 0.01)/1e+20), ((V(L1_N272) + 0.01)/1.0)) }
Bd1d_273 L1_N273 0 I={ max(((V(L1_N273) - 0.01)/1e+20), ((V(L1_N273) - 0.01)/1.0)) }
Bd1u_273 L1_N273 0 I={ min(((V(L1_N273) + 0.01)/1e+20), ((V(L1_N273) + 0.01)/1.0)) }
Bd1d_274 L1_N274 0 I={ max(((V(L1_N274) - 0.01)/1e+20), ((V(L1_N274) - 0.01)/1.0)) }
Bd1u_274 L1_N274 0 I={ min(((V(L1_N274) + 0.01)/1e+20), ((V(L1_N274) + 0.01)/1.0)) }
Bd1d_275 L1_N275 0 I={ max(((V(L1_N275) - 0.01)/1e+20), ((V(L1_N275) - 0.01)/1.0)) }
Bd1u_275 L1_N275 0 I={ min(((V(L1_N275) + 0.01)/1e+20), ((V(L1_N275) + 0.01)/1.0)) }
Bd1d_276 L1_N276 0 I={ max(((V(L1_N276) - 0.01)/1e+20), ((V(L1_N276) - 0.01)/1.0)) }
Bd1u_276 L1_N276 0 I={ min(((V(L1_N276) + 0.01)/1e+20), ((V(L1_N276) + 0.01)/1.0)) }
Bd1d_277 L1_N277 0 I={ max(((V(L1_N277) - 0.01)/1e+20), ((V(L1_N277) - 0.01)/1.0)) }
Bd1u_277 L1_N277 0 I={ min(((V(L1_N277) + 0.01)/1e+20), ((V(L1_N277) + 0.01)/1.0)) }
Bd1d_278 L1_N278 0 I={ max(((V(L1_N278) - 0.01)/1e+20), ((V(L1_N278) - 0.01)/1.0)) }
Bd1u_278 L1_N278 0 I={ min(((V(L1_N278) + 0.01)/1e+20), ((V(L1_N278) + 0.01)/1.0)) }
Bd1d_279 L1_N279 0 I={ max(((V(L1_N279) - 0.01)/1e+20), ((V(L1_N279) - 0.01)/1.0)) }
Bd1u_279 L1_N279 0 I={ min(((V(L1_N279) + 0.01)/1e+20), ((V(L1_N279) + 0.01)/1.0)) }
Bd1d_280 L1_N280 0 I={ max(((V(L1_N280) - 0.01)/1e+20), ((V(L1_N280) - 0.01)/1.0)) }
Bd1u_280 L1_N280 0 I={ min(((V(L1_N280) + 0.01)/1e+20), ((V(L1_N280) + 0.01)/1.0)) }
Bd1d_281 L1_N281 0 I={ max(((V(L1_N281) - 0.01)/1e+20), ((V(L1_N281) - 0.01)/1.0)) }
Bd1u_281 L1_N281 0 I={ min(((V(L1_N281) + 0.01)/1e+20), ((V(L1_N281) + 0.01)/1.0)) }
Bd1d_282 L1_N282 0 I={ max(((V(L1_N282) - 0.01)/1e+20), ((V(L1_N282) - 0.01)/1.0)) }
Bd1u_282 L1_N282 0 I={ min(((V(L1_N282) + 0.01)/1e+20), ((V(L1_N282) + 0.01)/1.0)) }
Bd1d_283 L1_N283 0 I={ max(((V(L1_N283) - 0.01)/1e+20), ((V(L1_N283) - 0.01)/1.0)) }
Bd1u_283 L1_N283 0 I={ min(((V(L1_N283) + 0.01)/1e+20), ((V(L1_N283) + 0.01)/1.0)) }
Bd1d_284 L1_N284 0 I={ max(((V(L1_N284) - 0.01)/1e+20), ((V(L1_N284) - 0.01)/1.0)) }
Bd1u_284 L1_N284 0 I={ min(((V(L1_N284) + 0.01)/1e+20), ((V(L1_N284) + 0.01)/1.0)) }
Bd1d_285 L1_N285 0 I={ max(((V(L1_N285) - 0.01)/1e+20), ((V(L1_N285) - 0.01)/1.0)) }
Bd1u_285 L1_N285 0 I={ min(((V(L1_N285) + 0.01)/1e+20), ((V(L1_N285) + 0.01)/1.0)) }
Bd1d_286 L1_N286 0 I={ max(((V(L1_N286) - 0.01)/1e+20), ((V(L1_N286) - 0.01)/1.0)) }
Bd1u_286 L1_N286 0 I={ min(((V(L1_N286) + 0.01)/1e+20), ((V(L1_N286) + 0.01)/1.0)) }
Bd1d_287 L1_N287 0 I={ max(((V(L1_N287) - 0.01)/1e+20), ((V(L1_N287) - 0.01)/1.0)) }
Bd1u_287 L1_N287 0 I={ min(((V(L1_N287) + 0.01)/1e+20), ((V(L1_N287) + 0.01)/1.0)) }
Bd1d_288 L1_N288 0 I={ max(((V(L1_N288) - 0.01)/1e+20), ((V(L1_N288) - 0.01)/1.0)) }
Bd1u_288 L1_N288 0 I={ min(((V(L1_N288) + 0.01)/1e+20), ((V(L1_N288) + 0.01)/1.0)) }
Bd1d_289 L1_N289 0 I={ max(((V(L1_N289) - 0.01)/1e+20), ((V(L1_N289) - 0.01)/1.0)) }
Bd1u_289 L1_N289 0 I={ min(((V(L1_N289) + 0.01)/1e+20), ((V(L1_N289) + 0.01)/1.0)) }
Bd1d_290 L1_N290 0 I={ max(((V(L1_N290) - 0.01)/1e+20), ((V(L1_N290) - 0.01)/1.0)) }
Bd1u_290 L1_N290 0 I={ min(((V(L1_N290) + 0.01)/1e+20), ((V(L1_N290) + 0.01)/1.0)) }
Bd1d_291 L1_N291 0 I={ max(((V(L1_N291) - 0.01)/1e+20), ((V(L1_N291) - 0.01)/1.0)) }
Bd1u_291 L1_N291 0 I={ min(((V(L1_N291) + 0.01)/1e+20), ((V(L1_N291) + 0.01)/1.0)) }
Bd1d_292 L1_N292 0 I={ max(((V(L1_N292) - 0.01)/1e+20), ((V(L1_N292) - 0.01)/1.0)) }
Bd1u_292 L1_N292 0 I={ min(((V(L1_N292) + 0.01)/1e+20), ((V(L1_N292) + 0.01)/1.0)) }
Bd1d_293 L1_N293 0 I={ max(((V(L1_N293) - 0.01)/1e+20), ((V(L1_N293) - 0.01)/1.0)) }
Bd1u_293 L1_N293 0 I={ min(((V(L1_N293) + 0.01)/1e+20), ((V(L1_N293) + 0.01)/1.0)) }
Bd1d_294 L1_N294 0 I={ max(((V(L1_N294) - 0.01)/1e+20), ((V(L1_N294) - 0.01)/1.0)) }
Bd1u_294 L1_N294 0 I={ min(((V(L1_N294) + 0.01)/1e+20), ((V(L1_N294) + 0.01)/1.0)) }
Bd1d_295 L1_N295 0 I={ max(((V(L1_N295) - 0.01)/1e+20), ((V(L1_N295) - 0.01)/1.0)) }
Bd1u_295 L1_N295 0 I={ min(((V(L1_N295) + 0.01)/1e+20), ((V(L1_N295) + 0.01)/1.0)) }
Bd1d_296 L1_N296 0 I={ max(((V(L1_N296) - 0.01)/1e+20), ((V(L1_N296) - 0.01)/1.0)) }
Bd1u_296 L1_N296 0 I={ min(((V(L1_N296) + 0.01)/1e+20), ((V(L1_N296) + 0.01)/1.0)) }
Bd1d_297 L1_N297 0 I={ max(((V(L1_N297) - 0.01)/1e+20), ((V(L1_N297) - 0.01)/1.0)) }
Bd1u_297 L1_N297 0 I={ min(((V(L1_N297) + 0.01)/1e+20), ((V(L1_N297) + 0.01)/1.0)) }
Bd1d_298 L1_N298 0 I={ max(((V(L1_N298) - 0.01)/1e+20), ((V(L1_N298) - 0.01)/1.0)) }
Bd1u_298 L1_N298 0 I={ min(((V(L1_N298) + 0.01)/1e+20), ((V(L1_N298) + 0.01)/1.0)) }
Bd1d_299 L1_N299 0 I={ max(((V(L1_N299) - 0.01)/1e+20), ((V(L1_N299) - 0.01)/1.0)) }
Bd1u_299 L1_N299 0 I={ min(((V(L1_N299) + 0.01)/1e+20), ((V(L1_N299) + 0.01)/1.0)) }
Bd1d_300 L1_N300 0 I={ max(((V(L1_N300) - 0.01)/1e+20), ((V(L1_N300) - 0.01)/1.0)) }
Bd1u_300 L1_N300 0 I={ min(((V(L1_N300) + 0.01)/1e+20), ((V(L1_N300) + 0.01)/1.0)) }
Bd1d_301 L1_N301 0 I={ max(((V(L1_N301) - 0.01)/1e+20), ((V(L1_N301) - 0.01)/1.0)) }
Bd1u_301 L1_N301 0 I={ min(((V(L1_N301) + 0.01)/1e+20), ((V(L1_N301) + 0.01)/1.0)) }
Bd1d_302 L1_N302 0 I={ max(((V(L1_N302) - 0.01)/1e+20), ((V(L1_N302) - 0.01)/1.0)) }
Bd1u_302 L1_N302 0 I={ min(((V(L1_N302) + 0.01)/1e+20), ((V(L1_N302) + 0.01)/1.0)) }
Bd1d_303 L1_N303 0 I={ max(((V(L1_N303) - 0.01)/1e+20), ((V(L1_N303) - 0.01)/1.0)) }
Bd1u_303 L1_N303 0 I={ min(((V(L1_N303) + 0.01)/1e+20), ((V(L1_N303) + 0.01)/1.0)) }
Bd1d_304 L1_N304 0 I={ max(((V(L1_N304) - 0.01)/1e+20), ((V(L1_N304) - 0.01)/1.0)) }
Bd1u_304 L1_N304 0 I={ min(((V(L1_N304) + 0.01)/1e+20), ((V(L1_N304) + 0.01)/1.0)) }
Bd1d_305 L1_N305 0 I={ max(((V(L1_N305) - 0.01)/1e+20), ((V(L1_N305) - 0.01)/1.0)) }
Bd1u_305 L1_N305 0 I={ min(((V(L1_N305) + 0.01)/1e+20), ((V(L1_N305) + 0.01)/1.0)) }
Bd1d_306 L1_N306 0 I={ max(((V(L1_N306) - 0.01)/1e+20), ((V(L1_N306) - 0.01)/1.0)) }
Bd1u_306 L1_N306 0 I={ min(((V(L1_N306) + 0.01)/1e+20), ((V(L1_N306) + 0.01)/1.0)) }
Bd1d_307 L1_N307 0 I={ max(((V(L1_N307) - 0.01)/1e+20), ((V(L1_N307) - 0.01)/1.0)) }
Bd1u_307 L1_N307 0 I={ min(((V(L1_N307) + 0.01)/1e+20), ((V(L1_N307) + 0.01)/1.0)) }
Bd1d_308 L1_N308 0 I={ max(((V(L1_N308) - 0.01)/1e+20), ((V(L1_N308) - 0.01)/1.0)) }
Bd1u_308 L1_N308 0 I={ min(((V(L1_N308) + 0.01)/1e+20), ((V(L1_N308) + 0.01)/1.0)) }
Bd1d_309 L1_N309 0 I={ max(((V(L1_N309) - 0.01)/1e+20), ((V(L1_N309) - 0.01)/1.0)) }
Bd1u_309 L1_N309 0 I={ min(((V(L1_N309) + 0.01)/1e+20), ((V(L1_N309) + 0.01)/1.0)) }
Bd1d_310 L1_N310 0 I={ max(((V(L1_N310) - 0.01)/1e+20), ((V(L1_N310) - 0.01)/1.0)) }
Bd1u_310 L1_N310 0 I={ min(((V(L1_N310) + 0.01)/1e+20), ((V(L1_N310) + 0.01)/1.0)) }
Bd1d_311 L1_N311 0 I={ max(((V(L1_N311) - 0.01)/1e+20), ((V(L1_N311) - 0.01)/1.0)) }
Bd1u_311 L1_N311 0 I={ min(((V(L1_N311) + 0.01)/1e+20), ((V(L1_N311) + 0.01)/1.0)) }
Bd1d_312 L1_N312 0 I={ max(((V(L1_N312) - 0.01)/1e+20), ((V(L1_N312) - 0.01)/1.0)) }
Bd1u_312 L1_N312 0 I={ min(((V(L1_N312) + 0.01)/1e+20), ((V(L1_N312) + 0.01)/1.0)) }
Bd1d_313 L1_N313 0 I={ max(((V(L1_N313) - 0.01)/1e+20), ((V(L1_N313) - 0.01)/1.0)) }
Bd1u_313 L1_N313 0 I={ min(((V(L1_N313) + 0.01)/1e+20), ((V(L1_N313) + 0.01)/1.0)) }
Bd1d_314 L1_N314 0 I={ max(((V(L1_N314) - 0.01)/1e+20), ((V(L1_N314) - 0.01)/1.0)) }
Bd1u_314 L1_N314 0 I={ min(((V(L1_N314) + 0.01)/1e+20), ((V(L1_N314) + 0.01)/1.0)) }
Bd1d_315 L1_N315 0 I={ max(((V(L1_N315) - 0.01)/1e+20), ((V(L1_N315) - 0.01)/1.0)) }
Bd1u_315 L1_N315 0 I={ min(((V(L1_N315) + 0.01)/1e+20), ((V(L1_N315) + 0.01)/1.0)) }
Bd1d_316 L1_N316 0 I={ max(((V(L1_N316) - 0.01)/1e+20), ((V(L1_N316) - 0.01)/1.0)) }
Bd1u_316 L1_N316 0 I={ min(((V(L1_N316) + 0.01)/1e+20), ((V(L1_N316) + 0.01)/1.0)) }
Bd1d_317 L1_N317 0 I={ max(((V(L1_N317) - 0.01)/1e+20), ((V(L1_N317) - 0.01)/1.0)) }
Bd1u_317 L1_N317 0 I={ min(((V(L1_N317) + 0.01)/1e+20), ((V(L1_N317) + 0.01)/1.0)) }
Bd1d_318 L1_N318 0 I={ max(((V(L1_N318) - 0.01)/1e+20), ((V(L1_N318) - 0.01)/1.0)) }
Bd1u_318 L1_N318 0 I={ min(((V(L1_N318) + 0.01)/1e+20), ((V(L1_N318) + 0.01)/1.0)) }
Bd1d_319 L1_N319 0 I={ max(((V(L1_N319) - 0.01)/1e+20), ((V(L1_N319) - 0.01)/1.0)) }
Bd1u_319 L1_N319 0 I={ min(((V(L1_N319) + 0.01)/1e+20), ((V(L1_N319) + 0.01)/1.0)) }
Bd1d_320 L1_N320 0 I={ max(((V(L1_N320) - 0.01)/1e+20), ((V(L1_N320) - 0.01)/1.0)) }
Bd1u_320 L1_N320 0 I={ min(((V(L1_N320) + 0.01)/1e+20), ((V(L1_N320) + 0.01)/1.0)) }
Bd1d_321 L1_N321 0 I={ max(((V(L1_N321) - 0.01)/1e+20), ((V(L1_N321) - 0.01)/1.0)) }
Bd1u_321 L1_N321 0 I={ min(((V(L1_N321) + 0.01)/1e+20), ((V(L1_N321) + 0.01)/1.0)) }
Bd1d_322 L1_N322 0 I={ max(((V(L1_N322) - 0.01)/1e+20), ((V(L1_N322) - 0.01)/1.0)) }
Bd1u_322 L1_N322 0 I={ min(((V(L1_N322) + 0.01)/1e+20), ((V(L1_N322) + 0.01)/1.0)) }
Bd1d_323 L1_N323 0 I={ max(((V(L1_N323) - 0.01)/1e+20), ((V(L1_N323) - 0.01)/1.0)) }
Bd1u_323 L1_N323 0 I={ min(((V(L1_N323) + 0.01)/1e+20), ((V(L1_N323) + 0.01)/1.0)) }
Bd1d_324 L1_N324 0 I={ max(((V(L1_N324) - 0.01)/1e+20), ((V(L1_N324) - 0.01)/1.0)) }
Bd1u_324 L1_N324 0 I={ min(((V(L1_N324) + 0.01)/1e+20), ((V(L1_N324) + 0.01)/1.0)) }
Bd1d_325 L1_N325 0 I={ max(((V(L1_N325) - 0.01)/1e+20), ((V(L1_N325) - 0.01)/1.0)) }
Bd1u_325 L1_N325 0 I={ min(((V(L1_N325) + 0.01)/1e+20), ((V(L1_N325) + 0.01)/1.0)) }
Bd1d_326 L1_N326 0 I={ max(((V(L1_N326) - 0.01)/1e+20), ((V(L1_N326) - 0.01)/1.0)) }
Bd1u_326 L1_N326 0 I={ min(((V(L1_N326) + 0.01)/1e+20), ((V(L1_N326) + 0.01)/1.0)) }
Bd1d_327 L1_N327 0 I={ max(((V(L1_N327) - 0.01)/1e+20), ((V(L1_N327) - 0.01)/1.0)) }
Bd1u_327 L1_N327 0 I={ min(((V(L1_N327) + 0.01)/1e+20), ((V(L1_N327) + 0.01)/1.0)) }
Bd1d_328 L1_N328 0 I={ max(((V(L1_N328) - 0.01)/1e+20), ((V(L1_N328) - 0.01)/1.0)) }
Bd1u_328 L1_N328 0 I={ min(((V(L1_N328) + 0.01)/1e+20), ((V(L1_N328) + 0.01)/1.0)) }
Bd1d_329 L1_N329 0 I={ max(((V(L1_N329) - 0.01)/1e+20), ((V(L1_N329) - 0.01)/1.0)) }
Bd1u_329 L1_N329 0 I={ min(((V(L1_N329) + 0.01)/1e+20), ((V(L1_N329) + 0.01)/1.0)) }
Bd1d_330 L1_N330 0 I={ max(((V(L1_N330) - 0.01)/1e+20), ((V(L1_N330) - 0.01)/1.0)) }
Bd1u_330 L1_N330 0 I={ min(((V(L1_N330) + 0.01)/1e+20), ((V(L1_N330) + 0.01)/1.0)) }
Bd1d_331 L1_N331 0 I={ max(((V(L1_N331) - 0.01)/1e+20), ((V(L1_N331) - 0.01)/1.0)) }
Bd1u_331 L1_N331 0 I={ min(((V(L1_N331) + 0.01)/1e+20), ((V(L1_N331) + 0.01)/1.0)) }
Bd1d_332 L1_N332 0 I={ max(((V(L1_N332) - 0.01)/1e+20), ((V(L1_N332) - 0.01)/1.0)) }
Bd1u_332 L1_N332 0 I={ min(((V(L1_N332) + 0.01)/1e+20), ((V(L1_N332) + 0.01)/1.0)) }
Bd1d_333 L1_N333 0 I={ max(((V(L1_N333) - 0.01)/1e+20), ((V(L1_N333) - 0.01)/1.0)) }
Bd1u_333 L1_N333 0 I={ min(((V(L1_N333) + 0.01)/1e+20), ((V(L1_N333) + 0.01)/1.0)) }
Bd1d_334 L1_N334 0 I={ max(((V(L1_N334) - 0.01)/1e+20), ((V(L1_N334) - 0.01)/1.0)) }
Bd1u_334 L1_N334 0 I={ min(((V(L1_N334) + 0.01)/1e+20), ((V(L1_N334) + 0.01)/1.0)) }
Bd1d_335 L1_N335 0 I={ max(((V(L1_N335) - 0.01)/1e+20), ((V(L1_N335) - 0.01)/1.0)) }
Bd1u_335 L1_N335 0 I={ min(((V(L1_N335) + 0.01)/1e+20), ((V(L1_N335) + 0.01)/1.0)) }
Bd1d_336 L1_N336 0 I={ max(((V(L1_N336) - 0.01)/1e+20), ((V(L1_N336) - 0.01)/1.0)) }
Bd1u_336 L1_N336 0 I={ min(((V(L1_N336) + 0.01)/1e+20), ((V(L1_N336) + 0.01)/1.0)) }
Bd1d_337 L1_N337 0 I={ max(((V(L1_N337) - 0.01)/1e+20), ((V(L1_N337) - 0.01)/1.0)) }
Bd1u_337 L1_N337 0 I={ min(((V(L1_N337) + 0.01)/1e+20), ((V(L1_N337) + 0.01)/1.0)) }
*
R_Dense_2_0_0 L1_N0 L2_N0 1.9681195228e+05
R_Dense_2_1_0 L1_N1 L2_N0 4.6021259544e+05
R_Dense_2_2_0 L1_N2 L2_N0 4.9595064345e+05
R_Dense_2_3_0 L1_N3 L2_N0 1.0903710898e+05
R_Dense_2_4_0 L1_N4 L2_N0 1.4827975955e+05
R_Dense_2_5_0 L1_N5 L2_N0 2.2154876865e+05
R_Dense_2_6_0 L1_N6 L2_N0 7.2069852662e+05
R_Dense_2_7_0 L1_N7 L2_N0 1.0387151735e+05
R_Dense_2_8_0 L1_N8 L2_N0 1.3468603419e+05
R_Dense_2_9_0 L1_N9 L2_N0 1.1453958180e+05
R_Dense_2_10_0 L1_N10 L2_N0 1.2896785849e+05
R_Dense_2_11_0 L1_N11 L2_N0 1.2298523294e+06
R_Dense_2_12_0 L1_N12 L2_N0 2.5175246202e+05
R_Dense_2_13_0 L1_N13 L2_N0 2.0038095271e+05
R_Dense_2_14_0 L1_N14 L2_N0 1.1677895102e+05
R_Dense_2_15_0 L1_N15 L2_N0 1.2065033201e+06
R_Dense_2_16_0 L1_N16 L2_N0 4.9111027374e+05
R_Dense_2_17_0 L1_N17 L2_N0 8.1690542933e+05
R_Dense_2_18_0 L1_N18 L2_N0 1.0476936017e+06
R_Dense_2_19_0 L1_N19 L2_N0 1.9217982173e+05
R_Dense_2_20_0 L1_N20 L2_N0 1.8088525846e+05
R_Dense_2_21_0 L1_N21 L2_N0 1.0266149301e+05
R_Dense_2_22_0 L1_N22 L2_N0 1.9169107679e+05
R_Dense_2_23_0 L1_N23 L2_N0 3.9450890071e+05
R_Dense_2_24_0 L1_N24 L2_N0 1.1949239703e+05
R_Dense_2_25_0 L1_N25 L2_N0 1.9459146687e+05
R_Dense_2_26_0 L1_N26 L2_N0 1.2099121144e+05
R_Dense_2_27_0 L1_N27 L2_N0 1.0102504407e+05
R_Dense_2_28_0 L1_N28 L2_N0 1.1834531525e+05
R_Dense_2_29_0 L1_N29 L2_N0 2.1702001464e+05
R_Dense_2_30_0 L1_N30 L2_N0 1.0685058304e+05
R_Dense_2_31_0 L1_N31 L2_N0 6.2086379201e+05
R_Dense_2_32_0 L1_N32 L2_N0 1.2152706270e+05
R_Dense_2_33_0 L1_N33 L2_N0 5.1783396330e+05
R_Dense_2_34_0 L1_N34 L2_N0 3.2658096954e+05
R_Dense_2_35_0 L1_N35 L2_N0 2.5974708232e+06
R_Dense_2_36_0 L1_N36 L2_N0 1.0235303720e+05
R_Dense_2_37_0 L1_N37 L2_N0 2.3814531941e+05
R_Dense_2_38_0 L1_N38 L2_N0 1.3329291773e+05
R_Dense_2_39_0 L1_N39 L2_N0 2.4033850000e+05
R_Dense_2_40_0 L1_N40 L2_N0 1.1827897245e+05
R_Dense_2_41_0 L1_N41 L2_N0 1.8380242183e+05
R_Dense_2_42_0 L1_N42 L2_N0 3.1020724838e+05
R_Dense_2_43_0 L1_N43 L2_N0 9.1427443607e+05
R_Dense_2_44_0 L1_N44 L2_N0 2.9765783151e+05
R_Dense_2_45_0 L1_N45 L2_N0 1.7709599078e+05
R_Dense_2_46_0 L1_N46 L2_N0 8.3972926166e+05
R_Dense_2_47_0 L1_N47 L2_N0 1.6957040898e+05
R_Dense_2_48_0 L1_N48 L2_N0 1.1988041986e+05
R_Dense_2_49_0 L1_N49 L2_N0 1.1718387480e+05
R_Dense_2_50_0 L1_N50 L2_N0 1.1624416584e+05
R_Dense_2_51_0 L1_N51 L2_N0 1.1926741900e+05
R_Dense_2_52_0 L1_N52 L2_N0 4.4022403290e+05
R_Dense_2_53_0 L1_N53 L2_N0 1.3843884061e+05
R_Dense_2_54_0 L1_N54 L2_N0 1.2886280944e+05
R_Dense_2_55_0 L1_N55 L2_N0 9.7860904048e+05
R_Dense_2_56_0 L1_N56 L2_N0 1.1400036756e+05
R_Dense_2_57_0 L1_N57 L2_N0 2.3432085908e+05
R_Dense_2_58_0 L1_N58 L2_N0 1.0533418210e+05
R_Dense_2_59_0 L1_N59 L2_N0 2.2255913908e+05
R_Dense_2_60_0 L1_N60 L2_N0 2.8442229879e+05
R_Dense_2_61_0 L1_N61 L2_N0 1.1109836385e+05
R_Dense_2_62_0 L1_N62 L2_N0 5.3566215442e+05
R_Dense_2_63_0 L1_N63 L2_N0 4.6777965737e+05
R_Dense_2_64_0 L1_N64 L2_N0 4.5367117260e+05
R_Dense_2_65_0 L1_N65 L2_N0 9.5385650909e+05
R_Dense_2_66_0 L1_N66 L2_N0 1.0037564292e+05
R_Dense_2_67_0 L1_N67 L2_N0 2.4656676609e+05
R_Dense_2_68_0 L1_N68 L2_N0 1.2311040889e+05
R_Dense_2_69_0 L1_N69 L2_N0 3.0258967562e+05
R_Dense_2_70_0 L1_N70 L2_N0 5.4064076987e+05
R_Dense_2_71_0 L1_N71 L2_N0 1.4207660144e+06
R_Dense_2_72_0 L1_N72 L2_N0 1.2238258374e+05
R_Dense_2_73_0 L1_N73 L2_N0 1.1021463754e+05
R_Dense_2_74_0 L1_N74 L2_N0 1.5630119270e+05
R_Dense_2_75_0 L1_N75 L2_N0 3.7632691552e+05
R_Dense_2_76_0 L1_N76 L2_N0 1.3275523666e+05
R_Dense_2_77_0 L1_N77 L2_N0 1.0132127771e+05
R_Dense_2_78_0 L1_N78 L2_N0 2.4341906027e+06
R_Dense_2_79_0 L1_N79 L2_N0 4.5817874932e+05
R_Dense_2_80_0 L1_N80 L2_N0 1.7992046297e+05
R_Dense_2_81_0 L1_N81 L2_N0 1.6166815807e+05
R_Dense_2_82_0 L1_N82 L2_N0 1.0880161361e+05
R_Dense_2_83_0 L1_N83 L2_N0 1.0175029806e+05
R_Dense_2_84_0 L1_N84 L2_N0 2.0977495157e+05
R_Dense_2_85_0 L1_N85 L2_N0 1.4776628739e+05
R_Dense_2_86_0 L1_N86 L2_N0 2.1640662199e+05
R_Dense_2_87_0 L1_N87 L2_N0 4.6959334077e+05
R_Dense_2_88_0 L1_N88 L2_N0 1.0596466773e+06
R_Dense_2_89_0 L1_N89 L2_N0 1.6244252542e+05
R_Dense_2_90_0 L1_N90 L2_N0 2.2790403459e+05
R_Dense_2_91_0 L1_N91 L2_N0 6.7596957881e+05
R_Dense_2_92_0 L1_N92 L2_N0 2.2210115801e+05
R_Dense_2_93_0 L1_N93 L2_N0 9.1522740260e+05
R_Dense_2_94_0 L1_N94 L2_N0 9.6747998782e+05
R_Dense_2_95_0 L1_N95 L2_N0 1.8796711295e+05
R_Dense_2_96_0 L1_N96 L2_N0 4.1650430535e+05
R_Dense_2_97_0 L1_N97 L2_N0 1.0958178256e+05
R_Dense_2_98_0 L1_N98 L2_N0 1.4354325159e+05
R_Dense_2_99_0 L1_N99 L2_N0 1.9500163186e+05
R_Dense_2_100_0 L1_N100 L2_N0 1.8155142456e+05
R_Dense_2_101_0 L1_N101 L2_N0 3.8028525286e+05
R_Dense_2_102_0 L1_N102 L2_N0 1.1780710130e+05
R_Dense_2_103_0 L1_N103 L2_N0 8.0324923083e+05
R_Dense_2_104_0 L1_N104 L2_N0 1.0788723944e+05
R_Dense_2_105_0 L1_N105 L2_N0 2.2385704128e+05
R_Dense_2_106_0 L1_N106 L2_N0 5.4107391885e+06
R_Dense_2_107_0 L1_N107 L2_N0 6.3662706194e+05
R_Dense_2_108_0 L1_N108 L2_N0 1.3164586664e+05
R_Dense_2_109_0 L1_N109 L2_N0 2.6421992229e+05
R_Dense_2_110_0 L1_N110 L2_N0 1.5985802895e+05
R_Dense_2_111_0 L1_N111 L2_N0 1.1090901377e+05
R_Dense_2_112_0 L1_N112 L2_N0 1.4491059280e+05
R_Dense_2_113_0 L1_N113 L2_N0 5.0506383829e+05
R_Dense_2_114_0 L1_N114 L2_N0 1.1634524133e+05
R_Dense_2_115_0 L1_N115 L2_N0 2.0847630051e+05
R_Dense_2_116_0 L1_N116 L2_N0 2.4868751072e+05
R_Dense_2_117_0 L1_N117 L2_N0 3.5011468544e+05
R_Dense_2_118_0 L1_N118 L2_N0 1.4568920257e+05
R_Dense_2_119_0 L1_N119 L2_N0 4.9717371245e+05
R_Dense_2_120_0 L1_N120 L2_N0 2.1150052245e+05
R_Dense_2_121_0 L1_N121 L2_N0 1.1165223173e+05
R_Dense_2_122_0 L1_N122 L2_N0 2.8091548481e+05
R_Dense_2_123_0 L1_N123 L2_N0 2.7411574630e+05
R_Dense_2_124_0 L1_N124 L2_N0 1.1634537327e+05
R_Dense_2_125_0 L1_N125 L2_N0 1.0262776789e+05
R_Dense_2_126_0 L1_N126 L2_N0 1.0088711249e+05
R_Dense_2_127_0 L1_N127 L2_N0 3.2248331797e+05
R_Dense_2_128_0 L1_N128 L2_N0 2.9919326914e+05
R_Dense_2_129_0 L1_N129 L2_N0 2.0166752976e+05
R_Dense_2_130_0 L1_N130 L2_N0 2.8093480882e+05
R_Dense_2_131_0 L1_N131 L2_N0 9.0048095303e+05
R_Dense_2_132_0 L1_N132 L2_N0 2.3967234038e+05
R_Dense_2_133_0 L1_N133 L2_N0 1.4958119467e+06
R_Dense_2_134_0 L1_N134 L2_N0 1.9319338881e+05
R_Dense_2_135_0 L1_N135 L2_N0 1.3566888606e+05
R_Dense_2_136_0 L1_N136 L2_N0 4.9148068784e+05
R_Dense_2_137_0 L1_N137 L2_N0 1.1097466514e+05
R_Dense_2_138_0 L1_N138 L2_N0 5.0074508159e+05
R_Dense_2_139_0 L1_N139 L2_N0 2.3033022934e+05
R_Dense_2_140_0 L1_N140 L2_N0 2.5322837564e+05
R_Dense_2_141_0 L1_N141 L2_N0 1.7648707035e+05
R_Dense_2_142_0 L1_N142 L2_N0 8.5058439171e+05
R_Dense_2_143_0 L1_N143 L2_N0 8.8768201658e+05
R_Dense_2_144_0 L1_N144 L2_N0 1.1781585215e+05
R_Dense_2_145_0 L1_N145 L2_N0 4.4174350655e+06
R_Dense_2_146_0 L1_N146 L2_N0 1.1067596312e+05
R_Dense_2_147_0 L1_N147 L2_N0 2.9560786605e+05
R_Dense_2_148_0 L1_N148 L2_N0 1.0610036872e+05
R_Dense_2_149_0 L1_N149 L2_N0 2.1440045211e+05
R_Dense_2_150_0 L1_N150 L2_N0 5.4113015308e+05
R_Dense_2_151_0 L1_N151 L2_N0 2.3401216228e+05
R_Dense_2_152_0 L1_N152 L2_N0 1.7756664306e+05
R_Dense_2_153_0 L1_N153 L2_N0 4.4742135336e+05
R_Dense_2_154_0 L1_N154 L2_N0 1.4071146942e+05
R_Dense_2_155_0 L1_N155 L2_N0 1.0668754373e+05
R_Dense_2_156_0 L1_N156 L2_N0 3.1822567251e+05
R_Dense_2_157_0 L1_N157 L2_N0 2.8172065349e+05
R_Dense_2_158_0 L1_N158 L2_N0 9.6289667627e+05
R_Dense_2_159_0 L1_N159 L2_N0 1.5256367177e+05
R_Dense_2_160_0 L1_N160 L2_N0 1.5840616254e+05
R_Dense_2_161_0 L1_N161 L2_N0 1.2920477586e+05
R_Dense_2_162_0 L1_N162 L2_N0 1.0075199365e+05
R_Dense_2_163_0 L1_N163 L2_N0 4.4905221806e+05
R_Dense_2_164_0 L1_N164 L2_N0 1.4242114529e+06
R_Dense_2_165_0 L1_N165 L2_N0 2.3121717924e+06
R_Dense_2_166_0 L1_N166 L2_N0 1.4158253855e+05
R_Dense_2_167_0 L1_N167 L2_N0 3.3407218939e+05
R_Dense_2_168_0 L1_N168 L2_N0 1.0395242849e+05
R_Dense_2_169_0 L1_N169 L2_N0 3.0197343823e+05
R_Dense_2_170_0 L1_N170 L2_N0 2.0577069960e+05
R_Dense_2_171_0 L1_N171 L2_N0 1.5227069994e+05
R_Dense_2_172_0 L1_N172 L2_N0 9.0894367618e+05
R_Dense_2_173_0 L1_N173 L2_N0 1.3328932573e+05
R_Dense_2_174_0 L1_N174 L2_N0 1.4153363827e+05
R_Dense_2_175_0 L1_N175 L2_N0 1.1647053155e+05
R_Dense_2_176_0 L1_N176 L2_N0 1.9388993874e+06
R_Dense_2_177_0 L1_N177 L2_N0 1.3337522458e+05
R_Dense_2_178_0 L1_N178 L2_N0 1.2049073857e+05
R_Dense_2_179_0 L1_N179 L2_N0 1.2350555884e+06
R_Dense_2_180_0 L1_N180 L2_N0 1.7098650099e+05
R_Dense_2_181_0 L1_N181 L2_N0 6.9657620679e+05
R_Dense_2_182_0 L1_N182 L2_N0 1.3319634192e+05
R_Dense_2_183_0 L1_N183 L2_N0 1.2316798778e+05
R_Dense_2_184_0 L1_N184 L2_N0 1.0605613517e+06
R_Dense_2_185_0 L1_N185 L2_N0 2.8806450228e+05
R_Dense_2_186_0 L1_N186 L2_N0 1.2638303940e+05
R_Dense_2_187_0 L1_N187 L2_N0 1.1139257557e+06
R_Dense_2_188_0 L1_N188 L2_N0 1.1779361471e+05
R_Dense_2_189_0 L1_N189 L2_N0 1.2881617071e+05
R_Dense_2_190_0 L1_N190 L2_N0 7.7439802620e+06
R_Dense_2_191_0 L1_N191 L2_N0 2.1961161586e+05
R_Dense_2_192_0 L1_N192 L2_N0 2.1089450159e+05
R_Dense_2_193_0 L1_N193 L2_N0 2.3859284491e+05
R_Dense_2_194_0 L1_N194 L2_N0 1.0578712502e+05
R_Dense_2_195_0 L1_N195 L2_N0 6.4822675856e+06
R_Dense_2_196_0 L1_N196 L2_N0 1.5313732021e+05
R_Dense_2_197_0 L1_N197 L2_N0 1.2042781375e+06
R_Dense_2_198_0 L1_N198 L2_N0 2.8693154926e+05
R_Dense_2_199_0 L1_N199 L2_N0 4.9243872478e+05
R_Dense_2_200_0 L1_N200 L2_N0 1.5403037174e+05
R_Dense_2_201_0 L1_N201 L2_N0 1.7344785791e+05
R_Dense_2_202_0 L1_N202 L2_N0 5.1607453588e+05
R_Dense_2_203_0 L1_N203 L2_N0 5.3334525933e+05
R_Dense_2_204_0 L1_N204 L2_N0 2.8554875211e+05
R_Dense_2_205_0 L1_N205 L2_N0 1.4088998678e+05
R_Dense_2_206_0 L1_N206 L2_N0 4.3494602028e+05
R_Dense_2_207_0 L1_N207 L2_N0 2.0578406028e+05
R_Dense_2_208_0 L1_N208 L2_N0 1.5245099319e+05
R_Dense_2_209_0 L1_N209 L2_N0 2.4006146611e+05
R_Dense_2_210_0 L1_N210 L2_N0 1.0757879622e+05
R_Dense_2_211_0 L1_N211 L2_N0 1.8301041797e+05
R_Dense_2_212_0 L1_N212 L2_N0 1.3756663676e+05
R_Dense_2_213_0 L1_N213 L2_N0 2.0983323780e+05
R_Dense_2_214_0 L1_N214 L2_N0 1.0098709966e+05
R_Dense_2_215_0 L1_N215 L2_N0 1.5684156303e+05
R_Dense_2_216_0 L1_N216 L2_N0 1.0323612450e+05
R_Dense_2_217_0 L1_N217 L2_N0 1.8071773224e+05
R_Dense_2_218_0 L1_N218 L2_N0 2.2736589670e+05
R_Dense_2_219_0 L1_N219 L2_N0 1.2164725681e+05
R_Dense_2_220_0 L1_N220 L2_N0 1.1716781708e+05
R_Dense_2_221_0 L1_N221 L2_N0 5.7396490104e+05
R_Dense_2_222_0 L1_N222 L2_N0 4.7597594661e+05
R_Dense_2_223_0 L1_N223 L2_N0 1.2020970800e+05
R_Dense_2_224_0 L1_N224 L2_N0 9.0257197151e+05
R_Dense_2_225_0 L1_N225 L2_N0 1.4607793097e+05
R_Dense_2_226_0 L1_N226 L2_N0 1.3752907085e+05
R_Dense_2_227_0 L1_N227 L2_N0 1.3220208915e+05
R_Dense_2_228_0 L1_N228 L2_N0 1.7397780971e+05
R_Dense_2_229_0 L1_N229 L2_N0 3.0776058838e+05
R_Dense_2_230_0 L1_N230 L2_N0 1.7548908275e+05
R_Dense_2_231_0 L1_N231 L2_N0 2.9111317343e+05
R_Dense_2_232_0 L1_N232 L2_N0 1.5542053983e+05
R_Dense_2_233_0 L1_N233 L2_N0 1.6566204554e+05
R_Dense_2_234_0 L1_N234 L2_N0 1.4311384829e+05
R_Dense_2_235_0 L1_N235 L2_N0 1.4402056982e+05
R_Dense_2_236_0 L1_N236 L2_N0 1.7339633132e+05
R_Dense_2_237_0 L1_N237 L2_N0 3.5558653084e+05
R_Dense_2_238_0 L1_N238 L2_N0 2.7138024772e+05
R_Dense_2_239_0 L1_N239 L2_N0 2.0848873838e+05
R_Dense_2_240_0 L1_N240 L2_N0 1.2309103063e+05
R_Dense_2_241_0 L1_N241 L2_N0 1.9783217384e+05
R_Dense_2_242_0 L1_N242 L2_N0 1.0970008709e+05
R_Dense_2_243_0 L1_N243 L2_N0 1.6266590226e+05
R_Dense_2_244_0 L1_N244 L2_N0 3.1522090153e+05
R_Dense_2_245_0 L1_N245 L2_N0 1.2593290698e+05
R_Dense_2_246_0 L1_N246 L2_N0 1.8337087912e+05
R_Dense_2_247_0 L1_N247 L2_N0 1.0724344687e+05
R_Dense_2_248_0 L1_N248 L2_N0 1.1284183207e+05
R_Dense_2_249_0 L1_N249 L2_N0 1.6019596361e+05
R_Dense_2_250_0 L1_N250 L2_N0 1.3460246057e+05
R_Dense_2_251_0 L1_N251 L2_N0 4.9994874467e+05
R_Dense_2_252_0 L1_N252 L2_N0 6.8863070210e+06
R_Dense_2_253_0 L1_N253 L2_N0 3.7833684236e+05
R_Dense_2_254_0 L1_N254 L2_N0 1.4775121297e+05
R_Dense_2_255_0 L1_N255 L2_N0 1.2194481664e+05
R_Dense_2_256_0 L1_N256 L2_N0 1.0353808564e+05
R_Dense_2_257_0 L1_N257 L2_N0 8.2315815233e+05
R_Dense_2_258_0 L1_N258 L2_N0 1.3315386863e+06
R_Dense_2_259_0 L1_N259 L2_N0 1.3536805528e+05
R_Dense_2_260_0 L1_N260 L2_N0 4.9022968308e+05
R_Dense_2_261_0 L1_N261 L2_N0 1.0039792052e+05
R_Dense_2_262_0 L1_N262 L2_N0 7.2641015739e+05
R_Dense_2_263_0 L1_N263 L2_N0 2.8042794165e+05
R_Dense_2_264_0 L1_N264 L2_N0 1.1141472202e+05
R_Dense_2_265_0 L1_N265 L2_N0 4.1161683546e+05
R_Dense_2_266_0 L1_N266 L2_N0 8.5439686932e+05
R_Dense_2_267_0 L1_N267 L2_N0 1.5587657749e+05
R_Dense_2_268_0 L1_N268 L2_N0 2.9608815424e+05
R_Dense_2_269_0 L1_N269 L2_N0 3.2623985275e+05
R_Dense_2_270_0 L1_N270 L2_N0 2.3327861106e+05
R_Dense_2_271_0 L1_N271 L2_N0 3.5784735468e+05
R_Dense_2_272_0 L1_N272 L2_N0 1.0565491118e+05
R_Dense_2_273_0 L1_N273 L2_N0 1.2130710962e+05
R_Dense_2_274_0 L1_N274 L2_N0 2.4190860919e+05
R_Dense_2_275_0 L1_N275 L2_N0 1.0366425827e+05
R_Dense_2_276_0 L1_N276 L2_N0 1.8195519629e+05
R_Dense_2_277_0 L1_N277 L2_N0 1.5329559833e+05
R_Dense_2_278_0 L1_N278 L2_N0 1.6311400558e+05
R_Dense_2_279_0 L1_N279 L2_N0 1.4970285053e+05
R_Dense_2_280_0 L1_N280 L2_N0 1.3813258465e+05
R_Dense_2_281_0 L1_N281 L2_N0 1.5621609747e+05
R_Dense_2_282_0 L1_N282 L2_N0 4.5179438578e+05
R_Dense_2_283_0 L1_N283 L2_N0 1.3637878339e+05
R_Dense_2_284_0 L1_N284 L2_N0 1.2502360070e+05
R_Dense_2_285_0 L1_N285 L2_N0 6.2956762801e+05
R_Dense_2_286_0 L1_N286 L2_N0 1.3705916342e+05
R_Dense_2_287_0 L1_N287 L2_N0 1.2589443972e+05
R_Dense_2_288_0 L1_N288 L2_N0 4.3683032332e+05
R_Dense_2_289_0 L1_N289 L2_N0 1.1920357197e+05
R_Dense_2_290_0 L1_N290 L2_N0 1.6897732940e+05
R_Dense_2_291_0 L1_N291 L2_N0 2.1317608584e+05
R_Dense_2_292_0 L1_N292 L2_N0 1.3538167496e+05
R_Dense_2_293_0 L1_N293 L2_N0 1.1925235145e+05
R_Dense_2_294_0 L1_N294 L2_N0 1.2419866722e+05
R_Dense_2_295_0 L1_N295 L2_N0 1.2466009728e+05
R_Dense_2_296_0 L1_N296 L2_N0 2.6587127600e+05
R_Dense_2_297_0 L1_N297 L2_N0 1.4918943933e+05
R_Dense_2_298_0 L1_N298 L2_N0 2.5513732288e+05
R_Dense_2_299_0 L1_N299 L2_N0 1.1926557143e+05
R_Dense_2_300_0 L1_N300 L2_N0 1.1941605675e+05
R_Dense_2_301_0 L1_N301 L2_N0 1.7413766361e+05
R_Dense_2_302_0 L1_N302 L2_N0 2.4499000775e+05
R_Dense_2_303_0 L1_N303 L2_N0 1.6585689998e+05
R_Dense_2_304_0 L1_N304 L2_N0 1.6508746300e+05
R_Dense_2_305_0 L1_N305 L2_N0 2.8492508871e+05
R_Dense_2_306_0 L1_N306 L2_N0 1.1447630991e+05
R_Dense_2_307_0 L1_N307 L2_N0 1.3675100766e+05
R_Dense_2_308_0 L1_N308 L2_N0 1.3573087200e+05
R_Dense_2_309_0 L1_N309 L2_N0 1.0960853608e+05
R_Dense_2_310_0 L1_N310 L2_N0 1.5346116266e+05
R_Dense_2_311_0 L1_N311 L2_N0 1.3612142666e+06
R_Dense_2_312_0 L1_N312 L2_N0 3.1612883686e+05
R_Dense_2_313_0 L1_N313 L2_N0 2.9977182489e+05
R_Dense_2_314_0 L1_N314 L2_N0 1.7373108880e+05
R_Dense_2_315_0 L1_N315 L2_N0 1.0741615694e+05
R_Dense_2_316_0 L1_N316 L2_N0 1.6326478859e+06
R_Dense_2_317_0 L1_N317 L2_N0 3.1289097183e+05
R_Dense_2_318_0 L1_N318 L2_N0 1.7889654212e+05
R_Dense_2_319_0 L1_N319 L2_N0 4.5121848837e+05
R_Dense_2_320_0 L1_N320 L2_N0 1.5070814668e+05
R_Dense_2_321_0 L1_N321 L2_N0 2.5872230159e+05
R_Dense_2_322_0 L1_N322 L2_N0 1.9010611658e+05
R_Dense_2_323_0 L1_N323 L2_N0 5.1553862461e+05
R_Dense_2_324_0 L1_N324 L2_N0 7.8999375203e+05
R_Dense_2_325_0 L1_N325 L2_N0 7.2446940233e+05
R_Dense_2_326_0 L1_N326 L2_N0 1.0134923928e+05
R_Dense_2_327_0 L1_N327 L2_N0 1.0018258975e+06
R_Dense_2_328_0 L1_N328 L2_N0 8.0857216167e+05
R_Dense_2_329_0 L1_N329 L2_N0 3.3652659738e+05
R_Dense_2_330_0 L1_N330 L2_N0 1.5503391579e+05
R_Dense_2_331_0 L1_N331 L2_N0 1.1575444290e+05
R_Dense_2_332_0 L1_N332 L2_N0 2.0423294300e+05
R_Dense_2_333_0 L1_N333 L2_N0 1.7267761708e+05
R_Dense_2_334_0 L1_N334 L2_N0 7.3989971450e+05
R_Dense_2_335_0 L1_N335 L2_N0 6.5058796119e+05
R_Dense_2_336_0 L1_N336 L2_N0 1.9827773371e+05
R_Dense_2_337_0 L1_N337 L2_N0 5.0944166106e+05
*
R_Dense_2_0_1 L1_N0 L2_N1 2.2051869360e+05
R_Dense_2_1_1 L1_N1 L2_N1 3.1769520645e+05
R_Dense_2_2_1 L1_N2 L2_N1 2.9366526116e+05
R_Dense_2_3_1 L1_N3 L2_N1 2.0071371037e+05
R_Dense_2_4_1 L1_N4 L2_N1 1.3193390641e+05
R_Dense_2_5_1 L1_N5 L2_N1 5.1477482689e+05
R_Dense_2_6_1 L1_N6 L2_N1 1.0047493102e+05
R_Dense_2_7_1 L1_N7 L2_N1 1.9250466755e+05
R_Dense_2_8_1 L1_N8 L2_N1 2.8946368554e+05
R_Dense_2_9_1 L1_N9 L2_N1 1.4387938693e+05
R_Dense_2_10_1 L1_N10 L2_N1 1.2145835158e+05
R_Dense_2_11_1 L1_N11 L2_N1 2.7190936738e+05
R_Dense_2_12_1 L1_N12 L2_N1 1.7373034841e+05
R_Dense_2_13_1 L1_N13 L2_N1 2.2410485954e+05
R_Dense_2_14_1 L1_N14 L2_N1 2.0523623875e+05
R_Dense_2_15_1 L1_N15 L2_N1 1.8298185322e+05
R_Dense_2_16_1 L1_N16 L2_N1 1.3121098647e+06
R_Dense_2_17_1 L1_N17 L2_N1 1.7176406981e+05
R_Dense_2_18_1 L1_N18 L2_N1 1.5633592777e+06
R_Dense_2_19_1 L1_N19 L2_N1 6.2665967936e+05
R_Dense_2_20_1 L1_N20 L2_N1 3.4736790446e+05
R_Dense_2_21_1 L1_N21 L2_N1 2.4489626240e+05
R_Dense_2_22_1 L1_N22 L2_N1 7.6662330829e+05
R_Dense_2_23_1 L1_N23 L2_N1 1.3874306049e+05
R_Dense_2_24_1 L1_N24 L2_N1 1.7164863652e+06
R_Dense_2_25_1 L1_N25 L2_N1 1.1716671868e+06
R_Dense_2_26_1 L1_N26 L2_N1 1.1189205433e+05
R_Dense_2_27_1 L1_N27 L2_N1 1.9157042589e+06
R_Dense_2_28_1 L1_N28 L2_N1 1.4413828667e+05
R_Dense_2_29_1 L1_N29 L2_N1 1.8002703458e+05
R_Dense_2_30_1 L1_N30 L2_N1 1.3882469853e+05
R_Dense_2_31_1 L1_N31 L2_N1 1.0070202258e+06
R_Dense_2_32_1 L1_N32 L2_N1 2.4555892515e+05
R_Dense_2_33_1 L1_N33 L2_N1 8.0457232671e+05
R_Dense_2_34_1 L1_N34 L2_N1 6.1584964411e+05
R_Dense_2_35_1 L1_N35 L2_N1 1.7513788925e+05
R_Dense_2_36_1 L1_N36 L2_N1 1.0008421643e+05
R_Dense_2_37_1 L1_N37 L2_N1 3.2789057484e+05
R_Dense_2_38_1 L1_N38 L2_N1 1.4083278805e+05
R_Dense_2_39_1 L1_N39 L2_N1 3.5462847507e+05
R_Dense_2_40_1 L1_N40 L2_N1 4.1717853472e+05
R_Dense_2_41_1 L1_N41 L2_N1 4.3297005353e+05
R_Dense_2_42_1 L1_N42 L2_N1 1.9124718025e+05
R_Dense_2_43_1 L1_N43 L2_N1 1.8111252625e+06
R_Dense_2_44_1 L1_N44 L2_N1 7.8021450696e+06
R_Dense_2_45_1 L1_N45 L2_N1 1.2923539622e+05
R_Dense_2_46_1 L1_N46 L2_N1 1.7468529190e+05
R_Dense_2_47_1 L1_N47 L2_N1 1.2271299222e+05
R_Dense_2_48_1 L1_N48 L2_N1 1.7638606356e+05
R_Dense_2_49_1 L1_N49 L2_N1 3.1216745769e+05
R_Dense_2_50_1 L1_N50 L2_N1 3.0238306804e+05
R_Dense_2_51_1 L1_N51 L2_N1 1.0048322333e+05
R_Dense_2_52_1 L1_N52 L2_N1 3.5183880184e+06
R_Dense_2_53_1 L1_N53 L2_N1 1.5520724729e+05
R_Dense_2_54_1 L1_N54 L2_N1 2.4436527195e+05
R_Dense_2_55_1 L1_N55 L2_N1 1.2489097209e+05
R_Dense_2_56_1 L1_N56 L2_N1 1.6673424917e+05
R_Dense_2_57_1 L1_N57 L2_N1 1.6013158157e+05
R_Dense_2_58_1 L1_N58 L2_N1 5.3045023278e+05
R_Dense_2_59_1 L1_N59 L2_N1 1.2848796820e+05
R_Dense_2_60_1 L1_N60 L2_N1 1.1520348486e+05
R_Dense_2_61_1 L1_N61 L2_N1 1.1261091240e+05
R_Dense_2_62_1 L1_N62 L2_N1 1.7749234673e+05
R_Dense_2_63_1 L1_N63 L2_N1 2.2823992887e+05
R_Dense_2_64_1 L1_N64 L2_N1 1.1202638726e+05
R_Dense_2_65_1 L1_N65 L2_N1 4.3772354090e+05
R_Dense_2_66_1 L1_N66 L2_N1 1.0604187284e+05
R_Dense_2_67_1 L1_N67 L2_N1 1.3777608897e+05
R_Dense_2_68_1 L1_N68 L2_N1 3.2422971760e+05
R_Dense_2_69_1 L1_N69 L2_N1 1.2608217685e+05
R_Dense_2_70_1 L1_N70 L2_N1 1.0025611307e+05
R_Dense_2_71_1 L1_N71 L2_N1 1.7232188028e+05
R_Dense_2_72_1 L1_N72 L2_N1 2.6666815804e+05
R_Dense_2_73_1 L1_N73 L2_N1 1.5374310842e+05
R_Dense_2_74_1 L1_N74 L2_N1 1.1179879389e+05
R_Dense_2_75_1 L1_N75 L2_N1 1.1289383298e+05
R_Dense_2_76_1 L1_N76 L2_N1 1.2806637819e+05
R_Dense_2_77_1 L1_N77 L2_N1 1.3919613550e+05
R_Dense_2_78_1 L1_N78 L2_N1 2.2084261421e+06
R_Dense_2_79_1 L1_N79 L2_N1 1.0943835211e+06
R_Dense_2_80_1 L1_N80 L2_N1 1.1568059537e+05
R_Dense_2_81_1 L1_N81 L2_N1 1.8412855659e+05
R_Dense_2_82_1 L1_N82 L2_N1 1.3273641881e+05
R_Dense_2_83_1 L1_N83 L2_N1 2.0991521360e+05
R_Dense_2_84_1 L1_N84 L2_N1 5.5928338363e+05
R_Dense_2_85_1 L1_N85 L2_N1 2.0795277891e+05
R_Dense_2_86_1 L1_N86 L2_N1 4.5055784740e+05
R_Dense_2_87_1 L1_N87 L2_N1 5.3083488433e+05
R_Dense_2_88_1 L1_N88 L2_N1 5.4337061837e+05
R_Dense_2_89_1 L1_N89 L2_N1 1.7419363501e+05
R_Dense_2_90_1 L1_N90 L2_N1 1.0681351837e+05
R_Dense_2_91_1 L1_N91 L2_N1 1.0098890000e+05
R_Dense_2_92_1 L1_N92 L2_N1 4.8578201330e+05
R_Dense_2_93_1 L1_N93 L2_N1 1.1571805634e+05
R_Dense_2_94_1 L1_N94 L2_N1 2.7087259931e+05
R_Dense_2_95_1 L1_N95 L2_N1 3.9917239775e+05
R_Dense_2_96_1 L1_N96 L2_N1 6.4164600535e+05
R_Dense_2_97_1 L1_N97 L2_N1 1.7954922698e+05
R_Dense_2_98_1 L1_N98 L2_N1 1.1282343444e+05
R_Dense_2_99_1 L1_N99 L2_N1 1.4520775173e+05
R_Dense_2_100_1 L1_N100 L2_N1 1.1751717643e+06
R_Dense_2_101_1 L1_N101 L2_N1 2.1947345309e+05
R_Dense_2_102_1 L1_N102 L2_N1 1.4257265160e+05
R_Dense_2_103_1 L1_N103 L2_N1 3.0390763636e+05
R_Dense_2_104_1 L1_N104 L2_N1 1.8387998085e+05
R_Dense_2_105_1 L1_N105 L2_N1 3.3666780935e+05
R_Dense_2_106_1 L1_N106 L2_N1 4.8890919232e+05
R_Dense_2_107_1 L1_N107 L2_N1 1.6451845075e+05
R_Dense_2_108_1 L1_N108 L2_N1 2.1531934001e+05
R_Dense_2_109_1 L1_N109 L2_N1 1.1346612638e+05
R_Dense_2_110_1 L1_N110 L2_N1 1.6672947750e+05
R_Dense_2_111_1 L1_N111 L2_N1 2.1530212583e+05
R_Dense_2_112_1 L1_N112 L2_N1 7.8772561215e+05
R_Dense_2_113_1 L1_N113 L2_N1 3.0156534268e+05
R_Dense_2_114_1 L1_N114 L2_N1 1.4785862945e+05
R_Dense_2_115_1 L1_N115 L2_N1 1.8565662254e+05
R_Dense_2_116_1 L1_N116 L2_N1 3.1159704680e+05
R_Dense_2_117_1 L1_N117 L2_N1 1.6658507775e+05
R_Dense_2_118_1 L1_N118 L2_N1 2.8468318882e+05
R_Dense_2_119_1 L1_N119 L2_N1 1.2519870717e+05
R_Dense_2_120_1 L1_N120 L2_N1 4.4059154998e+05
R_Dense_2_121_1 L1_N121 L2_N1 1.2358234803e+05
R_Dense_2_122_1 L1_N122 L2_N1 1.4830881300e+05
R_Dense_2_123_1 L1_N123 L2_N1 1.1054338503e+05
R_Dense_2_124_1 L1_N124 L2_N1 1.3697231008e+05
R_Dense_2_125_1 L1_N125 L2_N1 3.7724253844e+05
R_Dense_2_126_1 L1_N126 L2_N1 1.0577013820e+05
R_Dense_2_127_1 L1_N127 L2_N1 1.4508836634e+05
R_Dense_2_128_1 L1_N128 L2_N1 1.2667485131e+05
R_Dense_2_129_1 L1_N129 L2_N1 1.5276415931e+06
R_Dense_2_130_1 L1_N130 L2_N1 1.9711962182e+05
R_Dense_2_131_1 L1_N131 L2_N1 1.6539039635e+05
R_Dense_2_132_1 L1_N132 L2_N1 1.5939431598e+05
R_Dense_2_133_1 L1_N133 L2_N1 2.8802876258e+05
R_Dense_2_134_1 L1_N134 L2_N1 4.9065384116e+05
R_Dense_2_135_1 L1_N135 L2_N1 2.1565919430e+05
R_Dense_2_136_1 L1_N136 L2_N1 1.4581847816e+05
R_Dense_2_137_1 L1_N137 L2_N1 8.5096689734e+05
R_Dense_2_138_1 L1_N138 L2_N1 1.1949377695e+05
R_Dense_2_139_1 L1_N139 L2_N1 1.9090458290e+05
R_Dense_2_140_1 L1_N140 L2_N1 1.8542781385e+05
R_Dense_2_141_1 L1_N141 L2_N1 8.5380903984e+05
R_Dense_2_142_1 L1_N142 L2_N1 1.8474761192e+05
R_Dense_2_143_1 L1_N143 L2_N1 1.4301425019e+05
R_Dense_2_144_1 L1_N144 L2_N1 3.5799734359e+05
R_Dense_2_145_1 L1_N145 L2_N1 1.3750801677e+05
R_Dense_2_146_1 L1_N146 L2_N1 1.2145789687e+06
R_Dense_2_147_1 L1_N147 L2_N1 4.7085554089e+05
R_Dense_2_148_1 L1_N148 L2_N1 1.1734472718e+05
R_Dense_2_149_1 L1_N149 L2_N1 3.0785505713e+05
R_Dense_2_150_1 L1_N150 L2_N1 1.1217620736e+05
R_Dense_2_151_1 L1_N151 L2_N1 1.4138713043e+05
R_Dense_2_152_1 L1_N152 L2_N1 1.7419772092e+05
R_Dense_2_153_1 L1_N153 L2_N1 4.6474250118e+05
R_Dense_2_154_1 L1_N154 L2_N1 1.5493091784e+05
R_Dense_2_155_1 L1_N155 L2_N1 2.3452572025e+05
R_Dense_2_156_1 L1_N156 L2_N1 2.2497881152e+05
R_Dense_2_157_1 L1_N157 L2_N1 2.2830246394e+05
R_Dense_2_158_1 L1_N158 L2_N1 1.2707618265e+05
R_Dense_2_159_1 L1_N159 L2_N1 1.3045597966e+06
R_Dense_2_160_1 L1_N160 L2_N1 1.2207283436e+05
R_Dense_2_161_1 L1_N161 L2_N1 7.7201488896e+05
R_Dense_2_162_1 L1_N162 L2_N1 5.1996424125e+05
R_Dense_2_163_1 L1_N163 L2_N1 1.4344444974e+05
R_Dense_2_164_1 L1_N164 L2_N1 1.1286286641e+05
R_Dense_2_165_1 L1_N165 L2_N1 2.7239176273e+05
R_Dense_2_166_1 L1_N166 L2_N1 1.0330722596e+05
R_Dense_2_167_1 L1_N167 L2_N1 9.9410508284e+06
R_Dense_2_168_1 L1_N168 L2_N1 1.6101519624e+05
R_Dense_2_169_1 L1_N169 L2_N1 1.0406741897e+05
R_Dense_2_170_1 L1_N170 L2_N1 1.0330717656e+05
R_Dense_2_171_1 L1_N171 L2_N1 2.0071344704e+05
R_Dense_2_172_1 L1_N172 L2_N1 1.0212102504e+05
R_Dense_2_173_1 L1_N173 L2_N1 1.1590004554e+05
R_Dense_2_174_1 L1_N174 L2_N1 3.3314910893e+05
R_Dense_2_175_1 L1_N175 L2_N1 1.9231215474e+05
R_Dense_2_176_1 L1_N176 L2_N1 4.5135429442e+05
R_Dense_2_177_1 L1_N177 L2_N1 1.4825394191e+05
R_Dense_2_178_1 L1_N178 L2_N1 1.1241671796e+05
R_Dense_2_179_1 L1_N179 L2_N1 5.6093361227e+05
R_Dense_2_180_1 L1_N180 L2_N1 5.6016255978e+05
R_Dense_2_181_1 L1_N181 L2_N1 6.3714524628e+05
R_Dense_2_182_1 L1_N182 L2_N1 1.8295482002e+05
R_Dense_2_183_1 L1_N183 L2_N1 1.2408367365e+05
R_Dense_2_184_1 L1_N184 L2_N1 2.2622987237e+05
R_Dense_2_185_1 L1_N185 L2_N1 5.2153241992e+05
R_Dense_2_186_1 L1_N186 L2_N1 1.5507983765e+05
R_Dense_2_187_1 L1_N187 L2_N1 6.4895356841e+05
R_Dense_2_188_1 L1_N188 L2_N1 3.6218678058e+05
R_Dense_2_189_1 L1_N189 L2_N1 4.7539579181e+06
R_Dense_2_190_1 L1_N190 L2_N1 2.8111599908e+05
R_Dense_2_191_1 L1_N191 L2_N1 1.1959041373e+05
R_Dense_2_192_1 L1_N192 L2_N1 2.1178038760e+06
R_Dense_2_193_1 L1_N193 L2_N1 3.2158325025e+05
R_Dense_2_194_1 L1_N194 L2_N1 1.1911253553e+05
R_Dense_2_195_1 L1_N195 L2_N1 1.4646220328e+05
R_Dense_2_196_1 L1_N196 L2_N1 2.1072037468e+05
R_Dense_2_197_1 L1_N197 L2_N1 4.0405299807e+05
R_Dense_2_198_1 L1_N198 L2_N1 1.9420649382e+05
R_Dense_2_199_1 L1_N199 L2_N1 3.2725196338e+05
R_Dense_2_200_1 L1_N200 L2_N1 2.7862325138e+05
R_Dense_2_201_1 L1_N201 L2_N1 1.0283576709e+05
R_Dense_2_202_1 L1_N202 L2_N1 4.8816408530e+05
R_Dense_2_203_1 L1_N203 L2_N1 1.0749340498e+05
R_Dense_2_204_1 L1_N204 L2_N1 5.0081898509e+05
R_Dense_2_205_1 L1_N205 L2_N1 1.4966118898e+05
R_Dense_2_206_1 L1_N206 L2_N1 1.8179221712e+05
R_Dense_2_207_1 L1_N207 L2_N1 1.4747704701e+05
R_Dense_2_208_1 L1_N208 L2_N1 1.4973685021e+05
R_Dense_2_209_1 L1_N209 L2_N1 1.2724609579e+05
R_Dense_2_210_1 L1_N210 L2_N1 3.2811279331e+05
R_Dense_2_211_1 L1_N211 L2_N1 2.0522755331e+05
R_Dense_2_212_1 L1_N212 L2_N1 5.0679515758e+05
R_Dense_2_213_1 L1_N213 L2_N1 5.9795174357e+05
R_Dense_2_214_1 L1_N214 L2_N1 3.6060717975e+05
R_Dense_2_215_1 L1_N215 L2_N1 4.5599338491e+05
R_Dense_2_216_1 L1_N216 L2_N1 8.8658008853e+05
R_Dense_2_217_1 L1_N217 L2_N1 1.6866836969e+05
R_Dense_2_218_1 L1_N218 L2_N1 1.7092448489e+05
R_Dense_2_219_1 L1_N219 L2_N1 3.6853263579e+05
R_Dense_2_220_1 L1_N220 L2_N1 1.5240041552e+05
R_Dense_2_221_1 L1_N221 L2_N1 1.1424997229e+05
R_Dense_2_222_1 L1_N222 L2_N1 1.9604619973e+05
R_Dense_2_223_1 L1_N223 L2_N1 1.4351680214e+06
R_Dense_2_224_1 L1_N224 L2_N1 3.3276198174e+06
R_Dense_2_225_1 L1_N225 L2_N1 1.4636048432e+05
R_Dense_2_226_1 L1_N226 L2_N1 2.5898424534e+05
R_Dense_2_227_1 L1_N227 L2_N1 1.3381987816e+05
R_Dense_2_228_1 L1_N228 L2_N1 1.9650856433e+05
R_Dense_2_229_1 L1_N229 L2_N1 1.8183955197e+05
R_Dense_2_230_1 L1_N230 L2_N1 1.5015267287e+05
R_Dense_2_231_1 L1_N231 L2_N1 1.7612487546e+05
R_Dense_2_232_1 L1_N232 L2_N1 1.7772795076e+05
R_Dense_2_233_1 L1_N233 L2_N1 2.6085129500e+05
R_Dense_2_234_1 L1_N234 L2_N1 1.3905256292e+05
R_Dense_2_235_1 L1_N235 L2_N1 1.5937772562e+06
R_Dense_2_236_1 L1_N236 L2_N1 2.2007233497e+06
R_Dense_2_237_1 L1_N237 L2_N1 6.5575584661e+05
R_Dense_2_238_1 L1_N238 L2_N1 2.9193225978e+05
R_Dense_2_239_1 L1_N239 L2_N1 1.5779949434e+05
R_Dense_2_240_1 L1_N240 L2_N1 1.0052898530e+05
R_Dense_2_241_1 L1_N241 L2_N1 4.7208398186e+05
R_Dense_2_242_1 L1_N242 L2_N1 1.1109401444e+05
R_Dense_2_243_1 L1_N243 L2_N1 3.9674109555e+05
R_Dense_2_244_1 L1_N244 L2_N1 8.7889361350e+05
R_Dense_2_245_1 L1_N245 L2_N1 1.1343868576e+05
R_Dense_2_246_1 L1_N246 L2_N1 1.3047966483e+05
R_Dense_2_247_1 L1_N247 L2_N1 1.1443153202e+05
R_Dense_2_248_1 L1_N248 L2_N1 2.0617578122e+05
R_Dense_2_249_1 L1_N249 L2_N1 2.2348949516e+05
R_Dense_2_250_1 L1_N250 L2_N1 1.6118779363e+06
R_Dense_2_251_1 L1_N251 L2_N1 1.2560297083e+05
R_Dense_2_252_1 L1_N252 L2_N1 1.4288089273e+05
R_Dense_2_253_1 L1_N253 L2_N1 1.4065764290e+05
R_Dense_2_254_1 L1_N254 L2_N1 1.5917895531e+05
R_Dense_2_255_1 L1_N255 L2_N1 1.3225568824e+05
R_Dense_2_256_1 L1_N256 L2_N1 1.0050730617e+05
R_Dense_2_257_1 L1_N257 L2_N1 2.0567857097e+05
R_Dense_2_258_1 L1_N258 L2_N1 2.4038106185e+05
R_Dense_2_259_1 L1_N259 L2_N1 4.1923143170e+05
R_Dense_2_260_1 L1_N260 L2_N1 1.0874437866e+05
R_Dense_2_261_1 L1_N261 L2_N1 2.2450969948e+05
R_Dense_2_262_1 L1_N262 L2_N1 1.8739530096e+05
R_Dense_2_263_1 L1_N263 L2_N1 5.6237837395e+05
R_Dense_2_264_1 L1_N264 L2_N1 1.6010539466e+05
R_Dense_2_265_1 L1_N265 L2_N1 3.9899174822e+06
R_Dense_2_266_1 L1_N266 L2_N1 2.9244577862e+05
R_Dense_2_267_1 L1_N267 L2_N1 9.8042417984e+05
R_Dense_2_268_1 L1_N268 L2_N1 1.9319478281e+05
R_Dense_2_269_1 L1_N269 L2_N1 1.3644403612e+05
R_Dense_2_270_1 L1_N270 L2_N1 1.1864746832e+05
R_Dense_2_271_1 L1_N271 L2_N1 2.5758001226e+05
R_Dense_2_272_1 L1_N272 L2_N1 1.3230806992e+05
R_Dense_2_273_1 L1_N273 L2_N1 2.6576599703e+05
R_Dense_2_274_1 L1_N274 L2_N1 1.0383953596e+06
R_Dense_2_275_1 L1_N275 L2_N1 2.0334251136e+05
R_Dense_2_276_1 L1_N276 L2_N1 6.5704405099e+05
R_Dense_2_277_1 L1_N277 L2_N1 1.2880510613e+05
R_Dense_2_278_1 L1_N278 L2_N1 1.0908387527e+05
R_Dense_2_279_1 L1_N279 L2_N1 2.1742667659e+05
R_Dense_2_280_1 L1_N280 L2_N1 1.4011211650e+05
R_Dense_2_281_1 L1_N281 L2_N1 1.3963888663e+05
R_Dense_2_282_1 L1_N282 L2_N1 1.5327264475e+05
R_Dense_2_283_1 L1_N283 L2_N1 2.0233481810e+05
R_Dense_2_284_1 L1_N284 L2_N1 1.1499716453e+05
R_Dense_2_285_1 L1_N285 L2_N1 1.0317254418e+05
R_Dense_2_286_1 L1_N286 L2_N1 8.3888604378e+05
R_Dense_2_287_1 L1_N287 L2_N1 1.0610494593e+05
R_Dense_2_288_1 L1_N288 L2_N1 7.4850964632e+05
R_Dense_2_289_1 L1_N289 L2_N1 1.9895672981e+05
R_Dense_2_290_1 L1_N290 L2_N1 1.2157099896e+05
R_Dense_2_291_1 L1_N291 L2_N1 2.3674366822e+05
R_Dense_2_292_1 L1_N292 L2_N1 1.2867163340e+05
R_Dense_2_293_1 L1_N293 L2_N1 1.0915233653e+05
R_Dense_2_294_1 L1_N294 L2_N1 1.4046671318e+05
R_Dense_2_295_1 L1_N295 L2_N1 1.0616721894e+05
R_Dense_2_296_1 L1_N296 L2_N1 2.3294269591e+05
R_Dense_2_297_1 L1_N297 L2_N1 2.1461954572e+05
R_Dense_2_298_1 L1_N298 L2_N1 3.5527170301e+05
R_Dense_2_299_1 L1_N299 L2_N1 1.2486951244e+05
R_Dense_2_300_1 L1_N300 L2_N1 1.9164603310e+05
R_Dense_2_301_1 L1_N301 L2_N1 2.4145768694e+05
R_Dense_2_302_1 L1_N302 L2_N1 5.7042999896e+05
R_Dense_2_303_1 L1_N303 L2_N1 2.2062680192e+05
R_Dense_2_304_1 L1_N304 L2_N1 2.1273707253e+05
R_Dense_2_305_1 L1_N305 L2_N1 1.6670787823e+06
R_Dense_2_306_1 L1_N306 L2_N1 1.0771117916e+05
R_Dense_2_307_1 L1_N307 L2_N1 2.8881049477e+05
R_Dense_2_308_1 L1_N308 L2_N1 5.9352007522e+05
R_Dense_2_309_1 L1_N309 L2_N1 1.2678451090e+05
R_Dense_2_310_1 L1_N310 L2_N1 1.1886244546e+05
R_Dense_2_311_1 L1_N311 L2_N1 1.3426484327e+05
R_Dense_2_312_1 L1_N312 L2_N1 1.1950388247e+05
R_Dense_2_313_1 L1_N313 L2_N1 2.6495835854e+05
R_Dense_2_314_1 L1_N314 L2_N1 9.5880513313e+05
R_Dense_2_315_1 L1_N315 L2_N1 1.0340566565e+05
R_Dense_2_316_1 L1_N316 L2_N1 1.1481288500e+05
R_Dense_2_317_1 L1_N317 L2_N1 1.7330281730e+05
R_Dense_2_318_1 L1_N318 L2_N1 5.4143417331e+05
R_Dense_2_319_1 L1_N319 L2_N1 1.2848629745e+06
R_Dense_2_320_1 L1_N320 L2_N1 1.5846219669e+05
R_Dense_2_321_1 L1_N321 L2_N1 1.3232818108e+05
R_Dense_2_322_1 L1_N322 L2_N1 2.8376223171e+05
R_Dense_2_323_1 L1_N323 L2_N1 2.4276409694e+05
R_Dense_2_324_1 L1_N324 L2_N1 1.0860992426e+05
R_Dense_2_325_1 L1_N325 L2_N1 1.1271655638e+05
R_Dense_2_326_1 L1_N326 L2_N1 4.5782324454e+05
R_Dense_2_327_1 L1_N327 L2_N1 1.2642462951e+05
R_Dense_2_328_1 L1_N328 L2_N1 3.0476837695e+05
R_Dense_2_329_1 L1_N329 L2_N1 2.3203865142e+05
R_Dense_2_330_1 L1_N330 L2_N1 4.3798249954e+05
R_Dense_2_331_1 L1_N331 L2_N1 3.1106657032e+05
R_Dense_2_332_1 L1_N332 L2_N1 1.3919595626e+05
R_Dense_2_333_1 L1_N333 L2_N1 3.5075005817e+05
R_Dense_2_334_1 L1_N334 L2_N1 2.0406011979e+05
R_Dense_2_335_1 L1_N335 L2_N1 1.0235376407e+05
R_Dense_2_336_1 L1_N336 L2_N1 2.7194046580e+05
R_Dense_2_337_1 L1_N337 L2_N1 1.0564121238e+05
*
R_Dense_2_0_2 L1_N0 L2_N2 1.1754474411e+05
R_Dense_2_1_2 L1_N1 L2_N2 1.3061949160e+05
R_Dense_2_2_2 L1_N2 L2_N2 1.0798039574e+05
R_Dense_2_3_2 L1_N3 L2_N2 1.6523913593e+05
R_Dense_2_4_2 L1_N4 L2_N2 2.8235233752e+05
R_Dense_2_5_2 L1_N5 L2_N2 1.0888809362e+05
R_Dense_2_6_2 L1_N6 L2_N2 1.1213989020e+05
R_Dense_2_7_2 L1_N7 L2_N2 1.0700023304e+06
R_Dense_2_8_2 L1_N8 L2_N2 1.0653381258e+05
R_Dense_2_9_2 L1_N9 L2_N2 1.4397737972e+05
R_Dense_2_10_2 L1_N10 L2_N2 6.5389282325e+05
R_Dense_2_11_2 L1_N11 L2_N2 1.4844539909e+06
R_Dense_2_12_2 L1_N12 L2_N2 1.4499858227e+05
R_Dense_2_13_2 L1_N13 L2_N2 1.0828057121e+05
R_Dense_2_14_2 L1_N14 L2_N2 1.5628433293e+05
R_Dense_2_15_2 L1_N15 L2_N2 1.2700773234e+05
R_Dense_2_16_2 L1_N16 L2_N2 1.6083302857e+05
R_Dense_2_17_2 L1_N17 L2_N2 2.2786949161e+06
R_Dense_2_18_2 L1_N18 L2_N2 1.1064242339e+05
R_Dense_2_19_2 L1_N19 L2_N2 2.4419446231e+05
R_Dense_2_20_2 L1_N20 L2_N2 2.1203404469e+05
R_Dense_2_21_2 L1_N21 L2_N2 6.7592117885e+05
R_Dense_2_22_2 L1_N22 L2_N2 1.4916034250e+05
R_Dense_2_23_2 L1_N23 L2_N2 1.3275318681e+05
R_Dense_2_24_2 L1_N24 L2_N2 1.3096422346e+05
R_Dense_2_25_2 L1_N25 L2_N2 1.8012383139e+06
R_Dense_2_26_2 L1_N26 L2_N2 4.5491024890e+05
R_Dense_2_27_2 L1_N27 L2_N2 7.3426235694e+05
R_Dense_2_28_2 L1_N28 L2_N2 1.6998087548e+05
R_Dense_2_29_2 L1_N29 L2_N2 5.2985096794e+05
R_Dense_2_30_2 L1_N30 L2_N2 2.9561518799e+05
R_Dense_2_31_2 L1_N31 L2_N2 7.2725956329e+05
R_Dense_2_32_2 L1_N32 L2_N2 1.8949223728e+05
R_Dense_2_33_2 L1_N33 L2_N2 1.7557689606e+05
R_Dense_2_34_2 L1_N34 L2_N2 1.0488479484e+05
R_Dense_2_35_2 L1_N35 L2_N2 1.3043439645e+06
R_Dense_2_36_2 L1_N36 L2_N2 1.0121819356e+05
R_Dense_2_37_2 L1_N37 L2_N2 9.8813569940e+05
R_Dense_2_38_2 L1_N38 L2_N2 1.0177290702e+05
R_Dense_2_39_2 L1_N39 L2_N2 8.4243320690e+05
R_Dense_2_40_2 L1_N40 L2_N2 1.0819136270e+05
R_Dense_2_41_2 L1_N41 L2_N2 8.1698263006e+05
R_Dense_2_42_2 L1_N42 L2_N2 2.0384377170e+05
R_Dense_2_43_2 L1_N43 L2_N2 1.2735628475e+06
R_Dense_2_44_2 L1_N44 L2_N2 1.0527529818e+05
R_Dense_2_45_2 L1_N45 L2_N2 7.8057370064e+05
R_Dense_2_46_2 L1_N46 L2_N2 1.1519983564e+05
R_Dense_2_47_2 L1_N47 L2_N2 1.4588561989e+05
R_Dense_2_48_2 L1_N48 L2_N2 4.8791271856e+05
R_Dense_2_49_2 L1_N49 L2_N2 1.7374641373e+05
R_Dense_2_50_2 L1_N50 L2_N2 1.1606739501e+05
R_Dense_2_51_2 L1_N51 L2_N2 1.4940546119e+05
R_Dense_2_52_2 L1_N52 L2_N2 1.1492454061e+05
R_Dense_2_53_2 L1_N53 L2_N2 1.1376384210e+06
R_Dense_2_54_2 L1_N54 L2_N2 1.0929813237e+05
R_Dense_2_55_2 L1_N55 L2_N2 2.1864550833e+05
R_Dense_2_56_2 L1_N56 L2_N2 1.0284998422e+05
R_Dense_2_57_2 L1_N57 L2_N2 2.6240491442e+05
R_Dense_2_58_2 L1_N58 L2_N2 2.1381495855e+05
R_Dense_2_59_2 L1_N59 L2_N2 1.2705124894e+05
R_Dense_2_60_2 L1_N60 L2_N2 1.0408737211e+05
R_Dense_2_61_2 L1_N61 L2_N2 1.1661669860e+05
R_Dense_2_62_2 L1_N62 L2_N2 1.1732224213e+05
R_Dense_2_63_2 L1_N63 L2_N2 2.8644399797e+05
R_Dense_2_64_2 L1_N64 L2_N2 1.0470675777e+05
R_Dense_2_65_2 L1_N65 L2_N2 1.5934220141e+05
R_Dense_2_66_2 L1_N66 L2_N2 2.7254070149e+05
R_Dense_2_67_2 L1_N67 L2_N2 1.7033276858e+05
R_Dense_2_68_2 L1_N68 L2_N2 2.3635274464e+05
R_Dense_2_69_2 L1_N69 L2_N2 2.8648872705e+05
R_Dense_2_70_2 L1_N70 L2_N2 1.8181836657e+05
R_Dense_2_71_2 L1_N71 L2_N2 1.6203786808e+05
R_Dense_2_72_2 L1_N72 L2_N2 1.5680707266e+05
R_Dense_2_73_2 L1_N73 L2_N2 1.2049401687e+05
R_Dense_2_74_2 L1_N74 L2_N2 1.7620629536e+05
R_Dense_2_75_2 L1_N75 L2_N2 1.1678340294e+05
R_Dense_2_76_2 L1_N76 L2_N2 2.8779392642e+05
R_Dense_2_77_2 L1_N77 L2_N2 1.1877215794e+05
R_Dense_2_78_2 L1_N78 L2_N2 3.8152051044e+06
R_Dense_2_79_2 L1_N79 L2_N2 1.1438301759e+05
R_Dense_2_80_2 L1_N80 L2_N2 1.3174902165e+05
R_Dense_2_81_2 L1_N81 L2_N2 4.3735832670e+05
R_Dense_2_82_2 L1_N82 L2_N2 3.7253770642e+05
R_Dense_2_83_2 L1_N83 L2_N2 6.1266637073e+05
R_Dense_2_84_2 L1_N84 L2_N2 1.2825973635e+05
R_Dense_2_85_2 L1_N85 L2_N2 2.6540663366e+05
R_Dense_2_86_2 L1_N86 L2_N2 1.7107679176e+05
R_Dense_2_87_2 L1_N87 L2_N2 4.6075557362e+05
R_Dense_2_88_2 L1_N88 L2_N2 1.6538641694e+05
R_Dense_2_89_2 L1_N89 L2_N2 1.9496836221e+05
R_Dense_2_90_2 L1_N90 L2_N2 7.2932510185e+05
R_Dense_2_91_2 L1_N91 L2_N2 1.0993595953e+05
R_Dense_2_92_2 L1_N92 L2_N2 2.0772654456e+06
R_Dense_2_93_2 L1_N93 L2_N2 1.4628703212e+05
R_Dense_2_94_2 L1_N94 L2_N2 1.2368301276e+05
R_Dense_2_95_2 L1_N95 L2_N2 3.3101448567e+05
R_Dense_2_96_2 L1_N96 L2_N2 1.4590094769e+05
R_Dense_2_97_2 L1_N97 L2_N2 2.6417019108e+05
R_Dense_2_98_2 L1_N98 L2_N2 1.6080333681e+05
R_Dense_2_99_2 L1_N99 L2_N2 2.7849408116e+05
R_Dense_2_100_2 L1_N100 L2_N2 2.2213516608e+05
R_Dense_2_101_2 L1_N101 L2_N2 1.1220815425e+05
R_Dense_2_102_2 L1_N102 L2_N2 1.0775969017e+05
R_Dense_2_103_2 L1_N103 L2_N2 1.0595250651e+05
R_Dense_2_104_2 L1_N104 L2_N2 3.5868708441e+05
R_Dense_2_105_2 L1_N105 L2_N2 2.8041108505e+05
R_Dense_2_106_2 L1_N106 L2_N2 3.8248291429e+05
R_Dense_2_107_2 L1_N107 L2_N2 1.4774116689e+05
R_Dense_2_108_2 L1_N108 L2_N2 1.1824046219e+05
R_Dense_2_109_2 L1_N109 L2_N2 2.4994015756e+05
R_Dense_2_110_2 L1_N110 L2_N2 1.0830664458e+05
R_Dense_2_111_2 L1_N111 L2_N2 2.2158402304e+05
R_Dense_2_112_2 L1_N112 L2_N2 1.4313924114e+05
R_Dense_2_113_2 L1_N113 L2_N2 3.1018661262e+05
R_Dense_2_114_2 L1_N114 L2_N2 2.8472557215e+05
R_Dense_2_115_2 L1_N115 L2_N2 5.6667270046e+06
R_Dense_2_116_2 L1_N116 L2_N2 4.8268107098e+05
R_Dense_2_117_2 L1_N117 L2_N2 1.4352235782e+06
R_Dense_2_118_2 L1_N118 L2_N2 1.2798075328e+05
R_Dense_2_119_2 L1_N119 L2_N2 3.8790972648e+05
R_Dense_2_120_2 L1_N120 L2_N2 3.6475361032e+05
R_Dense_2_121_2 L1_N121 L2_N2 2.6962796597e+05
R_Dense_2_122_2 L1_N122 L2_N2 1.8438716234e+05
R_Dense_2_123_2 L1_N123 L2_N2 1.9507374265e+05
R_Dense_2_124_2 L1_N124 L2_N2 1.9484820403e+05
R_Dense_2_125_2 L1_N125 L2_N2 2.7663277691e+05
R_Dense_2_126_2 L1_N126 L2_N2 3.1394992092e+05
R_Dense_2_127_2 L1_N127 L2_N2 4.2941563194e+05
R_Dense_2_128_2 L1_N128 L2_N2 6.1949562302e+05
R_Dense_2_129_2 L1_N129 L2_N2 1.0165884078e+05
R_Dense_2_130_2 L1_N130 L2_N2 1.2242800441e+05
R_Dense_2_131_2 L1_N131 L2_N2 1.4582803917e+05
R_Dense_2_132_2 L1_N132 L2_N2 1.8132148592e+05
R_Dense_2_133_2 L1_N133 L2_N2 8.1389526268e+06
R_Dense_2_134_2 L1_N134 L2_N2 2.0725907861e+06
R_Dense_2_135_2 L1_N135 L2_N2 5.6453421710e+06
R_Dense_2_136_2 L1_N136 L2_N2 6.0558776454e+06
R_Dense_2_137_2 L1_N137 L2_N2 9.2341870228e+05
R_Dense_2_138_2 L1_N138 L2_N2 5.4792732528e+05
R_Dense_2_139_2 L1_N139 L2_N2 1.1777422179e+05
R_Dense_2_140_2 L1_N140 L2_N2 1.3162404078e+05
R_Dense_2_141_2 L1_N141 L2_N2 3.4289054606e+05
R_Dense_2_142_2 L1_N142 L2_N2 1.0012393989e+05
R_Dense_2_143_2 L1_N143 L2_N2 1.7644170948e+06
R_Dense_2_144_2 L1_N144 L2_N2 1.5538227196e+05
R_Dense_2_145_2 L1_N145 L2_N2 2.9695055756e+06
R_Dense_2_146_2 L1_N146 L2_N2 1.4112715769e+05
R_Dense_2_147_2 L1_N147 L2_N2 2.9362121751e+05
R_Dense_2_148_2 L1_N148 L2_N2 1.0427930518e+05
R_Dense_2_149_2 L1_N149 L2_N2 1.6267384469e+05
R_Dense_2_150_2 L1_N150 L2_N2 1.8941214241e+05
R_Dense_2_151_2 L1_N151 L2_N2 1.4675318194e+05
R_Dense_2_152_2 L1_N152 L2_N2 5.1265027055e+05
R_Dense_2_153_2 L1_N153 L2_N2 1.8244169909e+05
R_Dense_2_154_2 L1_N154 L2_N2 2.4551313335e+05
R_Dense_2_155_2 L1_N155 L2_N2 5.0749865608e+05
R_Dense_2_156_2 L1_N156 L2_N2 3.6157697597e+05
R_Dense_2_157_2 L1_N157 L2_N2 8.1943097149e+05
R_Dense_2_158_2 L1_N158 L2_N2 1.2258740676e+05
R_Dense_2_159_2 L1_N159 L2_N2 1.6011918354e+05
R_Dense_2_160_2 L1_N160 L2_N2 1.0597501846e+05
R_Dense_2_161_2 L1_N161 L2_N2 1.4175873076e+05
R_Dense_2_162_2 L1_N162 L2_N2 1.0240193094e+05
R_Dense_2_163_2 L1_N163 L2_N2 1.2861565791e+05
R_Dense_2_164_2 L1_N164 L2_N2 2.7860307250e+05
R_Dense_2_165_2 L1_N165 L2_N2 1.4509763869e+05
R_Dense_2_166_2 L1_N166 L2_N2 1.9774078803e+05
R_Dense_2_167_2 L1_N167 L2_N2 1.0090169394e+06
R_Dense_2_168_2 L1_N168 L2_N2 2.1477143103e+05
R_Dense_2_169_2 L1_N169 L2_N2 1.0212579440e+05
R_Dense_2_170_2 L1_N170 L2_N2 2.1442497650e+05
R_Dense_2_171_2 L1_N171 L2_N2 2.6563285551e+05
R_Dense_2_172_2 L1_N172 L2_N2 1.0401760195e+05
R_Dense_2_173_2 L1_N173 L2_N2 1.2930820932e+05
R_Dense_2_174_2 L1_N174 L2_N2 7.3974795275e+05
R_Dense_2_175_2 L1_N175 L2_N2 5.3075559663e+05
R_Dense_2_176_2 L1_N176 L2_N2 1.3070835469e+05
R_Dense_2_177_2 L1_N177 L2_N2 2.2836957958e+05
R_Dense_2_178_2 L1_N178 L2_N2 2.4100830563e+05
R_Dense_2_179_2 L1_N179 L2_N2 2.2544363964e+06
R_Dense_2_180_2 L1_N180 L2_N2 1.2479772479e+05
R_Dense_2_181_2 L1_N181 L2_N2 6.1199110830e+05
R_Dense_2_182_2 L1_N182 L2_N2 1.9408305973e+05
R_Dense_2_183_2 L1_N183 L2_N2 1.4988250938e+05
R_Dense_2_184_2 L1_N184 L2_N2 1.1229550852e+05
R_Dense_2_185_2 L1_N185 L2_N2 1.0538948139e+05
R_Dense_2_186_2 L1_N186 L2_N2 1.9196322259e+05
R_Dense_2_187_2 L1_N187 L2_N2 1.3688761852e+05
R_Dense_2_188_2 L1_N188 L2_N2 1.3246609004e+05
R_Dense_2_189_2 L1_N189 L2_N2 1.4727839405e+05
R_Dense_2_190_2 L1_N190 L2_N2 2.2565792851e+05
R_Dense_2_191_2 L1_N191 L2_N2 1.5835392155e+05
R_Dense_2_192_2 L1_N192 L2_N2 1.2835419213e+05
R_Dense_2_193_2 L1_N193 L2_N2 2.2686240223e+05
R_Dense_2_194_2 L1_N194 L2_N2 1.4393021481e+05
R_Dense_2_195_2 L1_N195 L2_N2 4.1510357778e+06
R_Dense_2_196_2 L1_N196 L2_N2 1.2224085771e+05
R_Dense_2_197_2 L1_N197 L2_N2 8.4610162858e+05
R_Dense_2_198_2 L1_N198 L2_N2 3.5903155378e+06
R_Dense_2_199_2 L1_N199 L2_N2 1.9782984930e+05
R_Dense_2_200_2 L1_N200 L2_N2 1.7528416842e+05
R_Dense_2_201_2 L1_N201 L2_N2 1.8275063951e+05
R_Dense_2_202_2 L1_N202 L2_N2 3.2571410557e+05
R_Dense_2_203_2 L1_N203 L2_N2 4.4656779406e+05
R_Dense_2_204_2 L1_N204 L2_N2 1.2370570032e+05
R_Dense_2_205_2 L1_N205 L2_N2 8.4910732138e+05
R_Dense_2_206_2 L1_N206 L2_N2 1.1916249292e+06
R_Dense_2_207_2 L1_N207 L2_N2 1.3388846436e+05
R_Dense_2_208_2 L1_N208 L2_N2 1.0328300348e+05
R_Dense_2_209_2 L1_N209 L2_N2 4.3194327350e+05
R_Dense_2_210_2 L1_N210 L2_N2 2.1714034287e+05
R_Dense_2_211_2 L1_N211 L2_N2 7.6056166248e+05
R_Dense_2_212_2 L1_N212 L2_N2 2.4546577600e+05
R_Dense_2_213_2 L1_N213 L2_N2 4.3972615420e+05
R_Dense_2_214_2 L1_N214 L2_N2 1.8212334491e+05
R_Dense_2_215_2 L1_N215 L2_N2 3.2036222296e+05
R_Dense_2_216_2 L1_N216 L2_N2 3.7102773335e+05
R_Dense_2_217_2 L1_N217 L2_N2 1.0756657299e+05
R_Dense_2_218_2 L1_N218 L2_N2 3.5790549575e+06
R_Dense_2_219_2 L1_N219 L2_N2 1.9830966282e+05
R_Dense_2_220_2 L1_N220 L2_N2 1.2459321464e+05
R_Dense_2_221_2 L1_N221 L2_N2 1.6593053008e+05
R_Dense_2_222_2 L1_N222 L2_N2 4.0516213829e+05
R_Dense_2_223_2 L1_N223 L2_N2 1.0728356365e+05
R_Dense_2_224_2 L1_N224 L2_N2 1.2717842768e+05
R_Dense_2_225_2 L1_N225 L2_N2 3.3786358453e+05
R_Dense_2_226_2 L1_N226 L2_N2 1.0830148096e+05
R_Dense_2_227_2 L1_N227 L2_N2 1.0153681319e+05
R_Dense_2_228_2 L1_N228 L2_N2 6.7337005888e+05
R_Dense_2_229_2 L1_N229 L2_N2 3.1996167415e+05
R_Dense_2_230_2 L1_N230 L2_N2 2.3271312649e+05
R_Dense_2_231_2 L1_N231 L2_N2 1.0145646603e+05
R_Dense_2_232_2 L1_N232 L2_N2 4.0229984313e+05
R_Dense_2_233_2 L1_N233 L2_N2 1.2241572348e+05
R_Dense_2_234_2 L1_N234 L2_N2 3.5974359905e+05
R_Dense_2_235_2 L1_N235 L2_N2 3.9781808090e+05
R_Dense_2_236_2 L1_N236 L2_N2 1.2528930021e+05
R_Dense_2_237_2 L1_N237 L2_N2 1.0469002511e+05
R_Dense_2_238_2 L1_N238 L2_N2 3.3489834070e+05
R_Dense_2_239_2 L1_N239 L2_N2 1.1326088408e+06
R_Dense_2_240_2 L1_N240 L2_N2 5.2497052662e+05
R_Dense_2_241_2 L1_N241 L2_N2 5.0820754281e+05
R_Dense_2_242_2 L1_N242 L2_N2 2.7589877192e+05
R_Dense_2_243_2 L1_N243 L2_N2 1.0781871071e+05
R_Dense_2_244_2 L1_N244 L2_N2 1.1563694356e+05
R_Dense_2_245_2 L1_N245 L2_N2 2.0501020791e+05
R_Dense_2_246_2 L1_N246 L2_N2 1.5981389198e+05
R_Dense_2_247_2 L1_N247 L2_N2 5.7340519681e+05
R_Dense_2_248_2 L1_N248 L2_N2 1.0296553638e+05
R_Dense_2_249_2 L1_N249 L2_N2 6.2558529868e+05
R_Dense_2_250_2 L1_N250 L2_N2 4.9593377524e+05
R_Dense_2_251_2 L1_N251 L2_N2 1.9384902708e+05
R_Dense_2_252_2 L1_N252 L2_N2 4.9159935682e+06
R_Dense_2_253_2 L1_N253 L2_N2 1.2925686907e+05
R_Dense_2_254_2 L1_N254 L2_N2 1.6566358410e+05
R_Dense_2_255_2 L1_N255 L2_N2 2.5664670277e+05
R_Dense_2_256_2 L1_N256 L2_N2 1.2276334366e+05
R_Dense_2_257_2 L1_N257 L2_N2 1.1812749973e+05
R_Dense_2_258_2 L1_N258 L2_N2 1.1023540856e+05
R_Dense_2_259_2 L1_N259 L2_N2 4.9518084146e+05
R_Dense_2_260_2 L1_N260 L2_N2 2.9469639212e+06
R_Dense_2_261_2 L1_N261 L2_N2 8.8723928004e+05
R_Dense_2_262_2 L1_N262 L2_N2 4.6509582882e+05
R_Dense_2_263_2 L1_N263 L2_N2 1.1797284039e+05
R_Dense_2_264_2 L1_N264 L2_N2 1.2822695561e+05
R_Dense_2_265_2 L1_N265 L2_N2 1.4355829658e+05
R_Dense_2_266_2 L1_N266 L2_N2 1.7772304051e+05
R_Dense_2_267_2 L1_N267 L2_N2 4.4100891058e+05
R_Dense_2_268_2 L1_N268 L2_N2 1.9123295858e+05
R_Dense_2_269_2 L1_N269 L2_N2 1.1252262510e+05
R_Dense_2_270_2 L1_N270 L2_N2 2.2131077255e+05
R_Dense_2_271_2 L1_N271 L2_N2 1.4134009239e+05
R_Dense_2_272_2 L1_N272 L2_N2 1.4351371418e+05
R_Dense_2_273_2 L1_N273 L2_N2 1.5337650164e+05
R_Dense_2_274_2 L1_N274 L2_N2 1.2151924051e+05
R_Dense_2_275_2 L1_N275 L2_N2 2.2409100029e+05
R_Dense_2_276_2 L1_N276 L2_N2 1.1501584382e+05
R_Dense_2_277_2 L1_N277 L2_N2 3.4493832983e+05
R_Dense_2_278_2 L1_N278 L2_N2 1.8113873414e+05
R_Dense_2_279_2 L1_N279 L2_N2 2.6165200274e+05
R_Dense_2_280_2 L1_N280 L2_N2 1.8181245242e+05
R_Dense_2_281_2 L1_N281 L2_N2 3.2238953308e+05
R_Dense_2_282_2 L1_N282 L2_N2 1.0767837493e+05
R_Dense_2_283_2 L1_N283 L2_N2 1.2813754674e+05
R_Dense_2_284_2 L1_N284 L2_N2 8.4920826948e+05
R_Dense_2_285_2 L1_N285 L2_N2 2.2261618639e+05
R_Dense_2_286_2 L1_N286 L2_N2 1.4248367422e+05
R_Dense_2_287_2 L1_N287 L2_N2 7.0715368081e+05
R_Dense_2_288_2 L1_N288 L2_N2 1.2399095819e+05
R_Dense_2_289_2 L1_N289 L2_N2 1.8783800804e+05
R_Dense_2_290_2 L1_N290 L2_N2 1.9556656622e+05
R_Dense_2_291_2 L1_N291 L2_N2 1.2065146581e+05
R_Dense_2_292_2 L1_N292 L2_N2 4.1243686842e+05
R_Dense_2_293_2 L1_N293 L2_N2 1.5672112218e+05
R_Dense_2_294_2 L1_N294 L2_N2 1.0695142627e+05
R_Dense_2_295_2 L1_N295 L2_N2 1.1295205628e+05
R_Dense_2_296_2 L1_N296 L2_N2 1.9278698588e+05
R_Dense_2_297_2 L1_N297 L2_N2 1.9562095476e+05
R_Dense_2_298_2 L1_N298 L2_N2 1.0011055737e+06
R_Dense_2_299_2 L1_N299 L2_N2 1.5980246239e+05
R_Dense_2_300_2 L1_N300 L2_N2 1.9578906669e+05
R_Dense_2_301_2 L1_N301 L2_N2 1.4373849612e+05
R_Dense_2_302_2 L1_N302 L2_N2 1.3717966688e+05
R_Dense_2_303_2 L1_N303 L2_N2 3.1493293961e+05
R_Dense_2_304_2 L1_N304 L2_N2 1.8501929773e+05
R_Dense_2_305_2 L1_N305 L2_N2 1.5046822198e+05
R_Dense_2_306_2 L1_N306 L2_N2 6.0683343079e+05
R_Dense_2_307_2 L1_N307 L2_N2 2.3531713469e+05
R_Dense_2_308_2 L1_N308 L2_N2 1.0949784593e+05
R_Dense_2_309_2 L1_N309 L2_N2 2.7188896472e+05
R_Dense_2_310_2 L1_N310 L2_N2 1.4597693178e+05
R_Dense_2_311_2 L1_N311 L2_N2 2.7642692441e+05
R_Dense_2_312_2 L1_N312 L2_N2 1.3202537384e+05
R_Dense_2_313_2 L1_N313 L2_N2 1.1696141785e+05
R_Dense_2_314_2 L1_N314 L2_N2 3.0639903373e+06
R_Dense_2_315_2 L1_N315 L2_N2 1.2407910154e+05
R_Dense_2_316_2 L1_N316 L2_N2 2.1928482422e+06
R_Dense_2_317_2 L1_N317 L2_N2 3.6406015810e+05
R_Dense_2_318_2 L1_N318 L2_N2 3.2125750920e+05
R_Dense_2_319_2 L1_N319 L2_N2 1.2909129046e+05
R_Dense_2_320_2 L1_N320 L2_N2 1.2057306939e+05
R_Dense_2_321_2 L1_N321 L2_N2 3.3325799568e+05
R_Dense_2_322_2 L1_N322 L2_N2 1.4696161664e+05
R_Dense_2_323_2 L1_N323 L2_N2 3.6533735226e+05
R_Dense_2_324_2 L1_N324 L2_N2 1.8239509335e+05
R_Dense_2_325_2 L1_N325 L2_N2 3.8357526676e+06
R_Dense_2_326_2 L1_N326 L2_N2 1.3545041124e+05
R_Dense_2_327_2 L1_N327 L2_N2 5.4941667793e+05
R_Dense_2_328_2 L1_N328 L2_N2 1.5638632103e+05
R_Dense_2_329_2 L1_N329 L2_N2 1.1771382588e+06
R_Dense_2_330_2 L1_N330 L2_N2 1.3077084275e+05
R_Dense_2_331_2 L1_N331 L2_N2 1.0991740790e+05
R_Dense_2_332_2 L1_N332 L2_N2 2.0228548747e+05
R_Dense_2_333_2 L1_N333 L2_N2 1.1151545949e+05
R_Dense_2_334_2 L1_N334 L2_N2 1.2938069197e+05
R_Dense_2_335_2 L1_N335 L2_N2 4.8068265737e+05
R_Dense_2_336_2 L1_N336 L2_N2 1.7252782296e+05
R_Dense_2_337_2 L1_N337 L2_N2 3.8754494104e+05
*
R_Dense_2_0_3 L1_N0 L2_N3 1.7293665955e+05
R_Dense_2_1_3 L1_N1 L2_N3 3.9943760532e+05
R_Dense_2_2_3 L1_N2 L2_N3 3.5433011767e+05
R_Dense_2_3_3 L1_N3 L2_N3 1.6649375676e+05
R_Dense_2_4_3 L1_N4 L2_N3 3.5291065362e+05
R_Dense_2_5_3 L1_N5 L2_N3 3.4071486543e+05
R_Dense_2_6_3 L1_N6 L2_N3 4.0678220040e+06
R_Dense_2_7_3 L1_N7 L2_N3 4.9939765155e+05
R_Dense_2_8_3 L1_N8 L2_N3 1.1031104005e+06
R_Dense_2_9_3 L1_N9 L2_N3 1.8083146235e+05
R_Dense_2_10_3 L1_N10 L2_N3 3.4322155569e+05
R_Dense_2_11_3 L1_N11 L2_N3 6.2210601576e+05
R_Dense_2_12_3 L1_N12 L2_N3 1.3690291806e+05
R_Dense_2_13_3 L1_N13 L2_N3 3.4236831406e+05
R_Dense_2_14_3 L1_N14 L2_N3 1.4982460153e+05
R_Dense_2_15_3 L1_N15 L2_N3 1.4220277717e+05
R_Dense_2_16_3 L1_N16 L2_N3 1.3246449773e+05
R_Dense_2_17_3 L1_N17 L2_N3 1.9851171493e+05
R_Dense_2_18_3 L1_N18 L2_N3 5.1861702164e+05
R_Dense_2_19_3 L1_N19 L2_N3 2.6042788390e+05
R_Dense_2_20_3 L1_N20 L2_N3 1.1701969041e+05
R_Dense_2_21_3 L1_N21 L2_N3 1.3630241589e+05
R_Dense_2_22_3 L1_N22 L2_N3 4.1379933715e+05
R_Dense_2_23_3 L1_N23 L2_N3 2.0637416015e+05
R_Dense_2_24_3 L1_N24 L2_N3 1.1498396739e+05
R_Dense_2_25_3 L1_N25 L2_N3 1.9972105393e+05
R_Dense_2_26_3 L1_N26 L2_N3 1.1366174139e+05
R_Dense_2_27_3 L1_N27 L2_N3 1.1499014708e+05
R_Dense_2_28_3 L1_N28 L2_N3 6.7515992883e+05
R_Dense_2_29_3 L1_N29 L2_N3 1.1940164201e+06
R_Dense_2_30_3 L1_N30 L2_N3 1.1177680942e+05
R_Dense_2_31_3 L1_N31 L2_N3 1.5269334986e+05
R_Dense_2_32_3 L1_N32 L2_N3 1.1329139644e+05
R_Dense_2_33_3 L1_N33 L2_N3 1.8602897807e+05
R_Dense_2_34_3 L1_N34 L2_N3 5.0382450856e+06
R_Dense_2_35_3 L1_N35 L2_N3 2.2932411009e+05
R_Dense_2_36_3 L1_N36 L2_N3 1.4524139829e+05
R_Dense_2_37_3 L1_N37 L2_N3 1.5921492550e+05
R_Dense_2_38_3 L1_N38 L2_N3 1.3495854713e+05
R_Dense_2_39_3 L1_N39 L2_N3 2.4389238586e+05
R_Dense_2_40_3 L1_N40 L2_N3 2.1037912765e+05
R_Dense_2_41_3 L1_N41 L2_N3 1.1711304991e+05
R_Dense_2_42_3 L1_N42 L2_N3 1.2108703402e+05
R_Dense_2_43_3 L1_N43 L2_N3 3.1487842547e+05
R_Dense_2_44_3 L1_N44 L2_N3 6.9594078932e+05
R_Dense_2_45_3 L1_N45 L2_N3 4.8552952598e+06
R_Dense_2_46_3 L1_N46 L2_N3 1.9888637370e+05
R_Dense_2_47_3 L1_N47 L2_N3 1.4885755615e+05
R_Dense_2_48_3 L1_N48 L2_N3 9.3114081836e+05
R_Dense_2_49_3 L1_N49 L2_N3 3.9096402816e+05
R_Dense_2_50_3 L1_N50 L2_N3 4.4416334656e+05
R_Dense_2_51_3 L1_N51 L2_N3 2.2530588440e+05
R_Dense_2_52_3 L1_N52 L2_N3 2.0599694365e+05
R_Dense_2_53_3 L1_N53 L2_N3 1.1116162703e+05
R_Dense_2_54_3 L1_N54 L2_N3 1.1279037148e+05
R_Dense_2_55_3 L1_N55 L2_N3 2.4123079565e+05
R_Dense_2_56_3 L1_N56 L2_N3 2.3708560704e+05
R_Dense_2_57_3 L1_N57 L2_N3 1.3015480061e+05
R_Dense_2_58_3 L1_N58 L2_N3 1.0307033772e+05
R_Dense_2_59_3 L1_N59 L2_N3 1.4646930868e+05
R_Dense_2_60_3 L1_N60 L2_N3 1.8620671570e+05
R_Dense_2_61_3 L1_N61 L2_N3 3.1368398752e+05
R_Dense_2_62_3 L1_N62 L2_N3 5.1720752028e+05
R_Dense_2_63_3 L1_N63 L2_N3 1.9328774774e+05
R_Dense_2_64_3 L1_N64 L2_N3 1.1748681733e+05
R_Dense_2_65_3 L1_N65 L2_N3 1.2623497238e+05
R_Dense_2_66_3 L1_N66 L2_N3 1.1559407116e+05
R_Dense_2_67_3 L1_N67 L2_N3 1.2050348352e+05
R_Dense_2_68_3 L1_N68 L2_N3 1.1965610487e+05
R_Dense_2_69_3 L1_N69 L2_N3 7.5955708329e+05
R_Dense_2_70_3 L1_N70 L2_N3 1.7257691282e+05
R_Dense_2_71_3 L1_N71 L2_N3 2.9432271723e+05
R_Dense_2_72_3 L1_N72 L2_N3 3.4911170190e+06
R_Dense_2_73_3 L1_N73 L2_N3 4.6607667749e+05
R_Dense_2_74_3 L1_N74 L2_N3 6.7503249987e+06
R_Dense_2_75_3 L1_N75 L2_N3 1.4548195759e+05
R_Dense_2_76_3 L1_N76 L2_N3 1.4958771780e+05
R_Dense_2_77_3 L1_N77 L2_N3 1.7904304602e+05
R_Dense_2_78_3 L1_N78 L2_N3 1.0584837415e+05
R_Dense_2_79_3 L1_N79 L2_N3 1.0604549475e+05
R_Dense_2_80_3 L1_N80 L2_N3 1.2385546337e+06
R_Dense_2_81_3 L1_N81 L2_N3 3.2117973592e+05
R_Dense_2_82_3 L1_N82 L2_N3 1.2768092319e+05
R_Dense_2_83_3 L1_N83 L2_N3 2.5396456916e+05
R_Dense_2_84_3 L1_N84 L2_N3 2.7228361820e+05
R_Dense_2_85_3 L1_N85 L2_N3 1.4484020531e+05
R_Dense_2_86_3 L1_N86 L2_N3 2.3028635687e+05
R_Dense_2_87_3 L1_N87 L2_N3 6.7277022526e+05
R_Dense_2_88_3 L1_N88 L2_N3 2.2989824882e+05
R_Dense_2_89_3 L1_N89 L2_N3 1.1579129431e+05
R_Dense_2_90_3 L1_N90 L2_N3 3.5495560476e+05
R_Dense_2_91_3 L1_N91 L2_N3 2.3756307956e+05
R_Dense_2_92_3 L1_N92 L2_N3 1.2207475737e+05
R_Dense_2_93_3 L1_N93 L2_N3 2.1843413688e+05
R_Dense_2_94_3 L1_N94 L2_N3 4.1567131133e+05
R_Dense_2_95_3 L1_N95 L2_N3 1.3668852242e+05
R_Dense_2_96_3 L1_N96 L2_N3 3.3285001234e+05
R_Dense_2_97_3 L1_N97 L2_N3 1.0339902758e+05
R_Dense_2_98_3 L1_N98 L2_N3 1.0322247198e+05
R_Dense_2_99_3 L1_N99 L2_N3 1.1286593118e+05
R_Dense_2_100_3 L1_N100 L2_N3 1.3313456892e+06
R_Dense_2_101_3 L1_N101 L2_N3 2.2175441657e+05
R_Dense_2_102_3 L1_N102 L2_N3 1.2588253981e+05
R_Dense_2_103_3 L1_N103 L2_N3 1.8807314154e+05
R_Dense_2_104_3 L1_N104 L2_N3 1.6978319951e+05
R_Dense_2_105_3 L1_N105 L2_N3 3.6440349166e+06
R_Dense_2_106_3 L1_N106 L2_N3 1.8684568692e+05
R_Dense_2_107_3 L1_N107 L2_N3 5.9061441029e+05
R_Dense_2_108_3 L1_N108 L2_N3 2.4167773755e+06
R_Dense_2_109_3 L1_N109 L2_N3 3.2433716640e+05
R_Dense_2_110_3 L1_N110 L2_N3 1.5098216989e+05
R_Dense_2_111_3 L1_N111 L2_N3 1.1230043005e+05
R_Dense_2_112_3 L1_N112 L2_N3 7.7406144354e+05
R_Dense_2_113_3 L1_N113 L2_N3 2.8619927689e+05
R_Dense_2_114_3 L1_N114 L2_N3 4.8836022840e+05
R_Dense_2_115_3 L1_N115 L2_N3 2.6404230675e+05
R_Dense_2_116_3 L1_N116 L2_N3 1.3743890950e+05
R_Dense_2_117_3 L1_N117 L2_N3 1.4184609623e+05
R_Dense_2_118_3 L1_N118 L2_N3 1.1466053045e+05
R_Dense_2_119_3 L1_N119 L2_N3 2.2428292238e+05
R_Dense_2_120_3 L1_N120 L2_N3 1.5690208464e+05
R_Dense_2_121_3 L1_N121 L2_N3 1.2883540476e+05
R_Dense_2_122_3 L1_N122 L2_N3 4.5386739876e+05
R_Dense_2_123_3 L1_N123 L2_N3 1.4254370619e+05
R_Dense_2_124_3 L1_N124 L2_N3 1.2990830020e+05
R_Dense_2_125_3 L1_N125 L2_N3 1.7285038478e+05
R_Dense_2_126_3 L1_N126 L2_N3 4.2360390936e+05
R_Dense_2_127_3 L1_N127 L2_N3 1.4092852919e+05
R_Dense_2_128_3 L1_N128 L2_N3 1.3993965698e+05
R_Dense_2_129_3 L1_N129 L2_N3 1.3082159363e+05
R_Dense_2_130_3 L1_N130 L2_N3 1.3937176293e+05
R_Dense_2_131_3 L1_N131 L2_N3 2.7965311912e+05
R_Dense_2_132_3 L1_N132 L2_N3 1.7983430850e+05
R_Dense_2_133_3 L1_N133 L2_N3 1.5228239429e+05
R_Dense_2_134_3 L1_N134 L2_N3 8.0081391153e+05
R_Dense_2_135_3 L1_N135 L2_N3 1.0125949914e+05
R_Dense_2_136_3 L1_N136 L2_N3 2.0449319970e+05
R_Dense_2_137_3 L1_N137 L2_N3 5.7675227758e+05
R_Dense_2_138_3 L1_N138 L2_N3 2.2356136814e+06
R_Dense_2_139_3 L1_N139 L2_N3 2.0412339802e+05
R_Dense_2_140_3 L1_N140 L2_N3 7.2208196697e+05
R_Dense_2_141_3 L1_N141 L2_N3 1.2929204384e+05
R_Dense_2_142_3 L1_N142 L2_N3 4.6652536764e+05
R_Dense_2_143_3 L1_N143 L2_N3 2.8488914340e+06
R_Dense_2_144_3 L1_N144 L2_N3 1.2361582901e+05
R_Dense_2_145_3 L1_N145 L2_N3 2.3740726714e+05
R_Dense_2_146_3 L1_N146 L2_N3 4.1481160956e+05
R_Dense_2_147_3 L1_N147 L2_N3 5.0673725580e+05
R_Dense_2_148_3 L1_N148 L2_N3 1.4536493952e+05
R_Dense_2_149_3 L1_N149 L2_N3 1.6350607403e+05
R_Dense_2_150_3 L1_N150 L2_N3 1.2470719158e+05
R_Dense_2_151_3 L1_N151 L2_N3 4.1959552848e+05
R_Dense_2_152_3 L1_N152 L2_N3 6.7218454779e+05
R_Dense_2_153_3 L1_N153 L2_N3 1.2833930391e+05
R_Dense_2_154_3 L1_N154 L2_N3 1.4507817727e+05
R_Dense_2_155_3 L1_N155 L2_N3 2.8371727152e+05
R_Dense_2_156_3 L1_N156 L2_N3 1.1843193133e+05
R_Dense_2_157_3 L1_N157 L2_N3 1.4062432037e+05
R_Dense_2_158_3 L1_N158 L2_N3 7.0800612215e+05
R_Dense_2_159_3 L1_N159 L2_N3 3.4963004591e+05
R_Dense_2_160_3 L1_N160 L2_N3 1.1368375800e+05
R_Dense_2_161_3 L1_N161 L2_N3 8.8118069349e+06
R_Dense_2_162_3 L1_N162 L2_N3 1.9646676836e+05
R_Dense_2_163_3 L1_N163 L2_N3 3.5044203288e+05
R_Dense_2_164_3 L1_N164 L2_N3 1.3071306874e+05
R_Dense_2_165_3 L1_N165 L2_N3 1.1482659624e+05
R_Dense_2_166_3 L1_N166 L2_N3 1.9797244828e+05
R_Dense_2_167_3 L1_N167 L2_N3 2.9677893395e+05
R_Dense_2_168_3 L1_N168 L2_N3 1.7038841878e+05
R_Dense_2_169_3 L1_N169 L2_N3 1.5403923354e+05
R_Dense_2_170_3 L1_N170 L2_N3 4.0982707681e+05
R_Dense_2_171_3 L1_N171 L2_N3 1.2031608168e+05
R_Dense_2_172_3 L1_N172 L2_N3 1.8891509997e+05
R_Dense_2_173_3 L1_N173 L2_N3 2.7350972549e+05
R_Dense_2_174_3 L1_N174 L2_N3 1.8584061489e+05
R_Dense_2_175_3 L1_N175 L2_N3 1.9898049552e+05
R_Dense_2_176_3 L1_N176 L2_N3 1.7638745486e+05
R_Dense_2_177_3 L1_N177 L2_N3 1.5857077671e+05
R_Dense_2_178_3 L1_N178 L2_N3 1.6982500832e+05
R_Dense_2_179_3 L1_N179 L2_N3 5.4668731758e+05
R_Dense_2_180_3 L1_N180 L2_N3 2.3049331411e+05
R_Dense_2_181_3 L1_N181 L2_N3 1.1244832350e+05
R_Dense_2_182_3 L1_N182 L2_N3 1.5131696342e+06
R_Dense_2_183_3 L1_N183 L2_N3 1.9151733469e+05
R_Dense_2_184_3 L1_N184 L2_N3 7.6234666466e+05
R_Dense_2_185_3 L1_N185 L2_N3 6.3655989631e+05
R_Dense_2_186_3 L1_N186 L2_N3 3.8887621657e+05
R_Dense_2_187_3 L1_N187 L2_N3 2.2234395869e+06
R_Dense_2_188_3 L1_N188 L2_N3 1.2346063202e+05
R_Dense_2_189_3 L1_N189 L2_N3 4.2957560472e+05
R_Dense_2_190_3 L1_N190 L2_N3 1.6240370336e+05
R_Dense_2_191_3 L1_N191 L2_N3 1.0660361619e+05
R_Dense_2_192_3 L1_N192 L2_N3 1.9102650603e+05
R_Dense_2_193_3 L1_N193 L2_N3 2.4270504117e+05
R_Dense_2_194_3 L1_N194 L2_N3 3.1168168444e+05
R_Dense_2_195_3 L1_N195 L2_N3 1.2915524096e+05
R_Dense_2_196_3 L1_N196 L2_N3 1.5988336165e+05
R_Dense_2_197_3 L1_N197 L2_N3 1.7062877937e+05
R_Dense_2_198_3 L1_N198 L2_N3 2.2271536623e+05
R_Dense_2_199_3 L1_N199 L2_N3 2.4183657996e+05
R_Dense_2_200_3 L1_N200 L2_N3 1.3914259164e+05
R_Dense_2_201_3 L1_N201 L2_N3 4.1882681688e+05
R_Dense_2_202_3 L1_N202 L2_N3 2.3733495028e+06
R_Dense_2_203_3 L1_N203 L2_N3 1.1722697206e+05
R_Dense_2_204_3 L1_N204 L2_N3 1.4947995407e+05
R_Dense_2_205_3 L1_N205 L2_N3 4.2908646364e+05
R_Dense_2_206_3 L1_N206 L2_N3 2.4853276057e+05
R_Dense_2_207_3 L1_N207 L2_N3 3.9359849920e+05
R_Dense_2_208_3 L1_N208 L2_N3 1.2732614960e+05
R_Dense_2_209_3 L1_N209 L2_N3 5.5733840477e+05
R_Dense_2_210_3 L1_N210 L2_N3 1.0149517797e+05
R_Dense_2_211_3 L1_N211 L2_N3 4.5700067346e+05
R_Dense_2_212_3 L1_N212 L2_N3 3.0046458315e+05
R_Dense_2_213_3 L1_N213 L2_N3 1.5923815639e+05
R_Dense_2_214_3 L1_N214 L2_N3 1.0891252658e+05
R_Dense_2_215_3 L1_N215 L2_N3 5.4223222251e+05
R_Dense_2_216_3 L1_N216 L2_N3 5.1974745669e+05
R_Dense_2_217_3 L1_N217 L2_N3 1.7498137600e+05
R_Dense_2_218_3 L1_N218 L2_N3 2.9455802949e+05
R_Dense_2_219_3 L1_N219 L2_N3 2.0222596992e+05
R_Dense_2_220_3 L1_N220 L2_N3 1.0212571843e+05
R_Dense_2_221_3 L1_N221 L2_N3 2.7466201484e+05
R_Dense_2_222_3 L1_N222 L2_N3 6.8634233196e+05
R_Dense_2_223_3 L1_N223 L2_N3 1.1435483782e+06
R_Dense_2_224_3 L1_N224 L2_N3 3.1009515975e+05
R_Dense_2_225_3 L1_N225 L2_N3 1.0370583897e+05
R_Dense_2_226_3 L1_N226 L2_N3 3.2679991858e+05
R_Dense_2_227_3 L1_N227 L2_N3 1.7338890073e+05
R_Dense_2_228_3 L1_N228 L2_N3 8.1512717792e+05
R_Dense_2_229_3 L1_N229 L2_N3 1.1348777622e+05
R_Dense_2_230_3 L1_N230 L2_N3 1.3175499555e+05
R_Dense_2_231_3 L1_N231 L2_N3 1.8797229269e+05
R_Dense_2_232_3 L1_N232 L2_N3 1.3926362398e+05
R_Dense_2_233_3 L1_N233 L2_N3 1.8246425274e+05
R_Dense_2_234_3 L1_N234 L2_N3 5.8699872195e+05
R_Dense_2_235_3 L1_N235 L2_N3 4.9945147718e+05
R_Dense_2_236_3 L1_N236 L2_N3 1.0837536894e+05
R_Dense_2_237_3 L1_N237 L2_N3 1.0230088275e+05
R_Dense_2_238_3 L1_N238 L2_N3 1.7904537992e+05
R_Dense_2_239_3 L1_N239 L2_N3 5.9039238401e+05
R_Dense_2_240_3 L1_N240 L2_N3 2.3878225513e+05
R_Dense_2_241_3 L1_N241 L2_N3 1.3549648468e+05
R_Dense_2_242_3 L1_N242 L2_N3 1.2705440808e+05
R_Dense_2_243_3 L1_N243 L2_N3 2.1426005799e+05
R_Dense_2_244_3 L1_N244 L2_N3 1.9071807798e+05
R_Dense_2_245_3 L1_N245 L2_N3 1.1685014178e+05
R_Dense_2_246_3 L1_N246 L2_N3 1.2399207216e+05
R_Dense_2_247_3 L1_N247 L2_N3 1.6454579269e+05
R_Dense_2_248_3 L1_N248 L2_N3 1.1323134397e+05
R_Dense_2_249_3 L1_N249 L2_N3 3.9225978411e+05
R_Dense_2_250_3 L1_N250 L2_N3 2.8902231695e+05
R_Dense_2_251_3 L1_N251 L2_N3 1.3855766467e+06
R_Dense_2_252_3 L1_N252 L2_N3 1.4282430937e+05
R_Dense_2_253_3 L1_N253 L2_N3 1.5923498975e+05
R_Dense_2_254_3 L1_N254 L2_N3 1.6383847436e+05
R_Dense_2_255_3 L1_N255 L2_N3 1.1159670220e+05
R_Dense_2_256_3 L1_N256 L2_N3 1.5183980045e+05
R_Dense_2_257_3 L1_N257 L2_N3 9.4777743743e+05
R_Dense_2_258_3 L1_N258 L2_N3 3.1161609588e+06
R_Dense_2_259_3 L1_N259 L2_N3 1.1992002480e+05
R_Dense_2_260_3 L1_N260 L2_N3 2.3839211602e+05
R_Dense_2_261_3 L1_N261 L2_N3 3.1965454968e+05
R_Dense_2_262_3 L1_N262 L2_N3 2.8402607588e+05
R_Dense_2_263_3 L1_N263 L2_N3 1.6573681856e+05
R_Dense_2_264_3 L1_N264 L2_N3 1.5540632983e+05
R_Dense_2_265_3 L1_N265 L2_N3 2.6444744291e+05
R_Dense_2_266_3 L1_N266 L2_N3 2.1078644304e+05
R_Dense_2_267_3 L1_N267 L2_N3 2.0803707176e+05
R_Dense_2_268_3 L1_N268 L2_N3 2.2990683410e+05
R_Dense_2_269_3 L1_N269 L2_N3 1.4278677240e+05
R_Dense_2_270_3 L1_N270 L2_N3 2.4090505316e+05
R_Dense_2_271_3 L1_N271 L2_N3 1.2057498412e+05
R_Dense_2_272_3 L1_N272 L2_N3 1.8461910401e+05
R_Dense_2_273_3 L1_N273 L2_N3 1.4383564299e+05
R_Dense_2_274_3 L1_N274 L2_N3 1.9211501674e+06
R_Dense_2_275_3 L1_N275 L2_N3 1.0775095069e+05
R_Dense_2_276_3 L1_N276 L2_N3 1.4584899184e+05
R_Dense_2_277_3 L1_N277 L2_N3 1.1919715684e+05
R_Dense_2_278_3 L1_N278 L2_N3 1.5915296608e+06
R_Dense_2_279_3 L1_N279 L2_N3 4.9057800994e+05
R_Dense_2_280_3 L1_N280 L2_N3 1.6530833254e+05
R_Dense_2_281_3 L1_N281 L2_N3 1.5062005209e+05
R_Dense_2_282_3 L1_N282 L2_N3 1.9570125422e+05
R_Dense_2_283_3 L1_N283 L2_N3 1.0063076017e+05
R_Dense_2_284_3 L1_N284 L2_N3 3.5866386443e+05
R_Dense_2_285_3 L1_N285 L2_N3 3.8682077834e+05
R_Dense_2_286_3 L1_N286 L2_N3 7.0836020262e+05
R_Dense_2_287_3 L1_N287 L2_N3 3.5110540638e+05
R_Dense_2_288_3 L1_N288 L2_N3 2.4037382267e+05
R_Dense_2_289_3 L1_N289 L2_N3 1.6370030080e+05
R_Dense_2_290_3 L1_N290 L2_N3 5.1306389445e+05
R_Dense_2_291_3 L1_N291 L2_N3 4.5469681682e+05
R_Dense_2_292_3 L1_N292 L2_N3 3.1719744599e+05
R_Dense_2_293_3 L1_N293 L2_N3 1.3813645054e+05
R_Dense_2_294_3 L1_N294 L2_N3 1.2746661596e+06
R_Dense_2_295_3 L1_N295 L2_N3 3.2917512918e+05
R_Dense_2_296_3 L1_N296 L2_N3 1.1346948257e+05
R_Dense_2_297_3 L1_N297 L2_N3 1.6088727112e+05
R_Dense_2_298_3 L1_N298 L2_N3 1.3543700091e+05
R_Dense_2_299_3 L1_N299 L2_N3 1.9503467433e+05
R_Dense_2_300_3 L1_N300 L2_N3 1.2633330537e+05
R_Dense_2_301_3 L1_N301 L2_N3 1.2988221439e+05
R_Dense_2_302_3 L1_N302 L2_N3 2.5432952388e+05
R_Dense_2_303_3 L1_N303 L2_N3 2.0753974474e+05
R_Dense_2_304_3 L1_N304 L2_N3 1.2099474066e+05
R_Dense_2_305_3 L1_N305 L2_N3 1.2418098452e+05
R_Dense_2_306_3 L1_N306 L2_N3 4.3829819988e+05
R_Dense_2_307_3 L1_N307 L2_N3 1.5252321990e+05
R_Dense_2_308_3 L1_N308 L2_N3 1.1071332856e+05
R_Dense_2_309_3 L1_N309 L2_N3 1.4606160383e+05
R_Dense_2_310_3 L1_N310 L2_N3 2.7369680554e+05
R_Dense_2_311_3 L1_N311 L2_N3 6.6585420884e+05
R_Dense_2_312_3 L1_N312 L2_N3 1.6534091396e+05
R_Dense_2_313_3 L1_N313 L2_N3 2.6934788132e+05
R_Dense_2_314_3 L1_N314 L2_N3 1.1162834514e+05
R_Dense_2_315_3 L1_N315 L2_N3 1.4624040381e+05
R_Dense_2_316_3 L1_N316 L2_N3 1.1161105346e+06
R_Dense_2_317_3 L1_N317 L2_N3 2.0988096843e+06
R_Dense_2_318_3 L1_N318 L2_N3 3.0021612945e+06
R_Dense_2_319_3 L1_N319 L2_N3 1.3854719506e+05
R_Dense_2_320_3 L1_N320 L2_N3 1.5394896859e+05
R_Dense_2_321_3 L1_N321 L2_N3 1.0010906350e+05
R_Dense_2_322_3 L1_N322 L2_N3 1.9334714817e+05
R_Dense_2_323_3 L1_N323 L2_N3 1.2025814580e+05
R_Dense_2_324_3 L1_N324 L2_N3 5.6526777246e+05
R_Dense_2_325_3 L1_N325 L2_N3 1.2984550016e+05
R_Dense_2_326_3 L1_N326 L2_N3 1.7104113188e+06
R_Dense_2_327_3 L1_N327 L2_N3 1.2325275131e+05
R_Dense_2_328_3 L1_N328 L2_N3 8.0063187889e+05
R_Dense_2_329_3 L1_N329 L2_N3 3.4821359045e+05
R_Dense_2_330_3 L1_N330 L2_N3 1.4472839490e+05
R_Dense_2_331_3 L1_N331 L2_N3 3.3976493254e+05
R_Dense_2_332_3 L1_N332 L2_N3 1.7715380438e+05
R_Dense_2_333_3 L1_N333 L2_N3 1.1656069520e+05
R_Dense_2_334_3 L1_N334 L2_N3 1.3430470425e+05
R_Dense_2_335_3 L1_N335 L2_N3 1.0465748560e+05
R_Dense_2_336_3 L1_N336 L2_N3 1.4609187003e+05
R_Dense_2_337_3 L1_N337 L2_N3 1.6709566910e+05
*
R_Dense_2_0_4 L1_N0 L2_N4 1.2561076098e+05
R_Dense_2_1_4 L1_N1 L2_N4 1.2506552293e+05
R_Dense_2_2_4 L1_N2 L2_N4 1.3435773890e+06
R_Dense_2_3_4 L1_N3 L2_N4 3.9959947988e+05
R_Dense_2_4_4 L1_N4 L2_N4 6.8581663729e+05
R_Dense_2_5_4 L1_N5 L2_N4 1.3484761919e+05
R_Dense_2_6_4 L1_N6 L2_N4 2.8367068486e+05
R_Dense_2_7_4 L1_N7 L2_N4 1.4149094235e+05
R_Dense_2_8_4 L1_N8 L2_N4 2.6881920155e+05
R_Dense_2_9_4 L1_N9 L2_N4 1.0411333886e+05
R_Dense_2_10_4 L1_N10 L2_N4 5.1598722155e+05
R_Dense_2_11_4 L1_N11 L2_N4 1.0664654110e+05
R_Dense_2_12_4 L1_N12 L2_N4 1.0448764797e+05
R_Dense_2_13_4 L1_N13 L2_N4 3.7174660511e+05
R_Dense_2_14_4 L1_N14 L2_N4 2.7506295544e+05
R_Dense_2_15_4 L1_N15 L2_N4 2.1974108103e+05
R_Dense_2_16_4 L1_N16 L2_N4 1.0565336997e+05
R_Dense_2_17_4 L1_N17 L2_N4 5.8904972614e+05
R_Dense_2_18_4 L1_N18 L2_N4 1.6827413857e+06
R_Dense_2_19_4 L1_N19 L2_N4 1.0307014168e+05
R_Dense_2_20_4 L1_N20 L2_N4 1.2595812624e+05
R_Dense_2_21_4 L1_N21 L2_N4 1.0011091553e+05
R_Dense_2_22_4 L1_N22 L2_N4 4.3062288298e+05
R_Dense_2_23_4 L1_N23 L2_N4 6.5341956461e+05
R_Dense_2_24_4 L1_N24 L2_N4 1.9887765433e+05
R_Dense_2_25_4 L1_N25 L2_N4 1.1406218618e+06
R_Dense_2_26_4 L1_N26 L2_N4 2.4449123923e+05
R_Dense_2_27_4 L1_N27 L2_N4 7.2145171448e+05
R_Dense_2_28_4 L1_N28 L2_N4 2.0927115826e+05
R_Dense_2_29_4 L1_N29 L2_N4 8.8555899513e+05
R_Dense_2_30_4 L1_N30 L2_N4 4.2933273598e+05
R_Dense_2_31_4 L1_N31 L2_N4 3.3195648855e+05
R_Dense_2_32_4 L1_N32 L2_N4 1.1663076525e+05
R_Dense_2_33_4 L1_N33 L2_N4 2.5110632698e+06
R_Dense_2_34_4 L1_N34 L2_N4 1.1385153807e+05
R_Dense_2_35_4 L1_N35 L2_N4 6.1968134965e+05
R_Dense_2_36_4 L1_N36 L2_N4 2.3127018151e+05
R_Dense_2_37_4 L1_N37 L2_N4 1.3007772778e+05
R_Dense_2_38_4 L1_N38 L2_N4 3.1227645874e+05
R_Dense_2_39_4 L1_N39 L2_N4 8.6958853461e+05
R_Dense_2_40_4 L1_N40 L2_N4 1.9007339485e+05
R_Dense_2_41_4 L1_N41 L2_N4 1.9725928664e+05
R_Dense_2_42_4 L1_N42 L2_N4 1.0971428036e+05
R_Dense_2_43_4 L1_N43 L2_N4 1.5280723753e+05
R_Dense_2_44_4 L1_N44 L2_N4 1.5147875988e+05
R_Dense_2_45_4 L1_N45 L2_N4 3.2734788591e+05
R_Dense_2_46_4 L1_N46 L2_N4 1.6560328871e+05
R_Dense_2_47_4 L1_N47 L2_N4 1.1190206466e+05
R_Dense_2_48_4 L1_N48 L2_N4 1.5072518421e+05
R_Dense_2_49_4 L1_N49 L2_N4 1.5987449538e+05
R_Dense_2_50_4 L1_N50 L2_N4 4.6579522544e+05
R_Dense_2_51_4 L1_N51 L2_N4 4.7139088950e+05
R_Dense_2_52_4 L1_N52 L2_N4 1.3688617514e+05
R_Dense_2_53_4 L1_N53 L2_N4 1.0645698777e+05
R_Dense_2_54_4 L1_N54 L2_N4 1.0161377629e+05
R_Dense_2_55_4 L1_N55 L2_N4 1.5902230910e+05
R_Dense_2_56_4 L1_N56 L2_N4 5.3200672178e+05
R_Dense_2_57_4 L1_N57 L2_N4 1.1560044689e+06
R_Dense_2_58_4 L1_N58 L2_N4 1.8267355645e+05
R_Dense_2_59_4 L1_N59 L2_N4 3.5269515140e+05
R_Dense_2_60_4 L1_N60 L2_N4 8.6931036550e+05
R_Dense_2_61_4 L1_N61 L2_N4 1.9128513276e+05
R_Dense_2_62_4 L1_N62 L2_N4 9.5128278510e+05
R_Dense_2_63_4 L1_N63 L2_N4 1.8089829495e+05
R_Dense_2_64_4 L1_N64 L2_N4 1.5890645560e+05
R_Dense_2_65_4 L1_N65 L2_N4 1.0047866058e+05
R_Dense_2_66_4 L1_N66 L2_N4 1.5261009691e+05
R_Dense_2_67_4 L1_N67 L2_N4 1.8257940871e+05
R_Dense_2_68_4 L1_N68 L2_N4 1.2262892499e+05
R_Dense_2_69_4 L1_N69 L2_N4 1.5517438917e+05
R_Dense_2_70_4 L1_N70 L2_N4 2.1502522499e+05
R_Dense_2_71_4 L1_N71 L2_N4 2.4901271704e+05
R_Dense_2_72_4 L1_N72 L2_N4 1.6031672296e+05
R_Dense_2_73_4 L1_N73 L2_N4 6.6902986767e+05
R_Dense_2_74_4 L1_N74 L2_N4 1.1440447705e+05
R_Dense_2_75_4 L1_N75 L2_N4 1.2247777725e+05
R_Dense_2_76_4 L1_N76 L2_N4 1.7327704473e+05
R_Dense_2_77_4 L1_N77 L2_N4 1.1448802844e+05
R_Dense_2_78_4 L1_N78 L2_N4 2.5924016001e+05
R_Dense_2_79_4 L1_N79 L2_N4 1.4346533207e+05
R_Dense_2_80_4 L1_N80 L2_N4 2.1914469511e+05
R_Dense_2_81_4 L1_N81 L2_N4 1.5394383185e+05
R_Dense_2_82_4 L1_N82 L2_N4 5.0861771862e+05
R_Dense_2_83_4 L1_N83 L2_N4 2.3542220905e+05
R_Dense_2_84_4 L1_N84 L2_N4 4.1989681106e+05
R_Dense_2_85_4 L1_N85 L2_N4 1.6459796602e+05
R_Dense_2_86_4 L1_N86 L2_N4 1.2688147364e+05
R_Dense_2_87_4 L1_N87 L2_N4 1.3033581598e+05
R_Dense_2_88_4 L1_N88 L2_N4 2.1044408907e+05
R_Dense_2_89_4 L1_N89 L2_N4 7.0955904788e+06
R_Dense_2_90_4 L1_N90 L2_N4 4.2842479448e+05
R_Dense_2_91_4 L1_N91 L2_N4 2.2827787092e+05
R_Dense_2_92_4 L1_N92 L2_N4 2.2892260632e+05
R_Dense_2_93_4 L1_N93 L2_N4 2.0040648321e+05
R_Dense_2_94_4 L1_N94 L2_N4 2.5361520118e+05
R_Dense_2_95_4 L1_N95 L2_N4 8.0638981686e+05
R_Dense_2_96_4 L1_N96 L2_N4 1.5712548171e+05
R_Dense_2_97_4 L1_N97 L2_N4 1.3903067145e+05
R_Dense_2_98_4 L1_N98 L2_N4 1.1460869017e+05
R_Dense_2_99_4 L1_N99 L2_N4 3.1035175072e+05
R_Dense_2_100_4 L1_N100 L2_N4 2.9279014703e+05
R_Dense_2_101_4 L1_N101 L2_N4 3.0530338093e+05
R_Dense_2_102_4 L1_N102 L2_N4 1.0439186368e+05
R_Dense_2_103_4 L1_N103 L2_N4 4.7223995668e+05
R_Dense_2_104_4 L1_N104 L2_N4 1.0734519939e+05
R_Dense_2_105_4 L1_N105 L2_N4 2.6606307040e+05
R_Dense_2_106_4 L1_N106 L2_N4 2.8791227077e+05
R_Dense_2_107_4 L1_N107 L2_N4 7.3731702592e+05
R_Dense_2_108_4 L1_N108 L2_N4 1.6084218383e+05
R_Dense_2_109_4 L1_N109 L2_N4 3.3883097808e+05
R_Dense_2_110_4 L1_N110 L2_N4 1.7814938407e+05
R_Dense_2_111_4 L1_N111 L2_N4 9.7659702131e+06
R_Dense_2_112_4 L1_N112 L2_N4 4.4057337808e+05
R_Dense_2_113_4 L1_N113 L2_N4 2.6672475664e+05
R_Dense_2_114_4 L1_N114 L2_N4 4.1100922589e+05
R_Dense_2_115_4 L1_N115 L2_N4 1.6435464146e+05
R_Dense_2_116_4 L1_N116 L2_N4 1.5240522961e+05
R_Dense_2_117_4 L1_N117 L2_N4 1.1442798528e+05
R_Dense_2_118_4 L1_N118 L2_N4 1.4301511199e+05
R_Dense_2_119_4 L1_N119 L2_N4 1.6651468011e+05
R_Dense_2_120_4 L1_N120 L2_N4 2.7182776941e+05
R_Dense_2_121_4 L1_N121 L2_N4 1.3858588756e+05
R_Dense_2_122_4 L1_N122 L2_N4 3.2644502683e+05
R_Dense_2_123_4 L1_N123 L2_N4 1.6373526806e+05
R_Dense_2_124_4 L1_N124 L2_N4 1.1514202904e+05
R_Dense_2_125_4 L1_N125 L2_N4 1.4397757855e+05
R_Dense_2_126_4 L1_N126 L2_N4 1.0156980993e+05
R_Dense_2_127_4 L1_N127 L2_N4 1.1652612190e+05
R_Dense_2_128_4 L1_N128 L2_N4 1.7940846770e+05
R_Dense_2_129_4 L1_N129 L2_N4 2.1285677796e+05
R_Dense_2_130_4 L1_N130 L2_N4 1.1960349928e+05
R_Dense_2_131_4 L1_N131 L2_N4 3.0212621163e+05
R_Dense_2_132_4 L1_N132 L2_N4 1.3636071301e+05
R_Dense_2_133_4 L1_N133 L2_N4 3.3670689614e+05
R_Dense_2_134_4 L1_N134 L2_N4 1.5428024507e+05
R_Dense_2_135_4 L1_N135 L2_N4 5.4352210993e+05
R_Dense_2_136_4 L1_N136 L2_N4 6.4952467501e+05
R_Dense_2_137_4 L1_N137 L2_N4 1.5828070972e+05
R_Dense_2_138_4 L1_N138 L2_N4 2.0186239534e+05
R_Dense_2_139_4 L1_N139 L2_N4 2.5768119207e+05
R_Dense_2_140_4 L1_N140 L2_N4 1.8957247099e+05
R_Dense_2_141_4 L1_N141 L2_N4 1.8045040757e+05
R_Dense_2_142_4 L1_N142 L2_N4 1.2740044677e+05
R_Dense_2_143_4 L1_N143 L2_N4 1.0400424563e+05
R_Dense_2_144_4 L1_N144 L2_N4 1.1134744968e+05
R_Dense_2_145_4 L1_N145 L2_N4 3.7761029607e+05
R_Dense_2_146_4 L1_N146 L2_N4 1.0252514265e+05
R_Dense_2_147_4 L1_N147 L2_N4 3.1647335182e+05
R_Dense_2_148_4 L1_N148 L2_N4 1.3658846024e+05
R_Dense_2_149_4 L1_N149 L2_N4 1.6778760897e+05
R_Dense_2_150_4 L1_N150 L2_N4 1.9531694106e+05
R_Dense_2_151_4 L1_N151 L2_N4 1.3849637561e+06
R_Dense_2_152_4 L1_N152 L2_N4 1.0227523454e+06
R_Dense_2_153_4 L1_N153 L2_N4 1.7896885138e+05
R_Dense_2_154_4 L1_N154 L2_N4 1.6497228940e+05
R_Dense_2_155_4 L1_N155 L2_N4 3.2595785480e+05
R_Dense_2_156_4 L1_N156 L2_N4 1.1917549858e+05
R_Dense_2_157_4 L1_N157 L2_N4 2.9425189951e+05
R_Dense_2_158_4 L1_N158 L2_N4 2.0182910778e+05
R_Dense_2_159_4 L1_N159 L2_N4 1.1780904972e+06
R_Dense_2_160_4 L1_N160 L2_N4 1.5583826710e+05
R_Dense_2_161_4 L1_N161 L2_N4 1.0493357044e+05
R_Dense_2_162_4 L1_N162 L2_N4 1.0677511941e+05
R_Dense_2_163_4 L1_N163 L2_N4 1.5439458495e+05
R_Dense_2_164_4 L1_N164 L2_N4 3.8308712191e+05
R_Dense_2_165_4 L1_N165 L2_N4 1.6888891257e+05
R_Dense_2_166_4 L1_N166 L2_N4 1.9948540866e+05
R_Dense_2_167_4 L1_N167 L2_N4 2.6043701671e+05
R_Dense_2_168_4 L1_N168 L2_N4 6.9694662554e+05
R_Dense_2_169_4 L1_N169 L2_N4 1.1329890990e+05
R_Dense_2_170_4 L1_N170 L2_N4 1.4555950377e+05
R_Dense_2_171_4 L1_N171 L2_N4 5.9065895024e+05
R_Dense_2_172_4 L1_N172 L2_N4 3.4558005914e+05
R_Dense_2_173_4 L1_N173 L2_N4 2.5214604276e+05
R_Dense_2_174_4 L1_N174 L2_N4 2.0736720226e+05
R_Dense_2_175_4 L1_N175 L2_N4 2.6046082536e+05
R_Dense_2_176_4 L1_N176 L2_N4 1.0682502756e+05
R_Dense_2_177_4 L1_N177 L2_N4 5.3260823014e+06
R_Dense_2_178_4 L1_N178 L2_N4 2.1183567361e+05
R_Dense_2_179_4 L1_N179 L2_N4 3.3150846148e+05
R_Dense_2_180_4 L1_N180 L2_N4 1.2125316092e+06
R_Dense_2_181_4 L1_N181 L2_N4 1.3186136463e+05
R_Dense_2_182_4 L1_N182 L2_N4 1.3795466785e+05
R_Dense_2_183_4 L1_N183 L2_N4 2.3106316601e+05
R_Dense_2_184_4 L1_N184 L2_N4 3.2612018085e+05
R_Dense_2_185_4 L1_N185 L2_N4 3.7314538401e+05
R_Dense_2_186_4 L1_N186 L2_N4 1.2613007830e+05
R_Dense_2_187_4 L1_N187 L2_N4 4.5767492097e+05
R_Dense_2_188_4 L1_N188 L2_N4 1.0129668675e+05
R_Dense_2_189_4 L1_N189 L2_N4 1.0772039665e+05
R_Dense_2_190_4 L1_N190 L2_N4 1.4112938983e+05
R_Dense_2_191_4 L1_N191 L2_N4 1.5948106089e+05
R_Dense_2_192_4 L1_N192 L2_N4 1.2487944611e+05
R_Dense_2_193_4 L1_N193 L2_N4 1.3063691596e+05
R_Dense_2_194_4 L1_N194 L2_N4 3.7354352086e+05
R_Dense_2_195_4 L1_N195 L2_N4 1.1037208191e+05
R_Dense_2_196_4 L1_N196 L2_N4 1.3358739274e+05
R_Dense_2_197_4 L1_N197 L2_N4 2.4291872965e+05
R_Dense_2_198_4 L1_N198 L2_N4 3.4446232202e+05
R_Dense_2_199_4 L1_N199 L2_N4 5.1686428270e+05
R_Dense_2_200_4 L1_N200 L2_N4 4.5867958002e+06
R_Dense_2_201_4 L1_N201 L2_N4 1.4372509536e+05
R_Dense_2_202_4 L1_N202 L2_N4 1.0445986065e+06
R_Dense_2_203_4 L1_N203 L2_N4 4.6077615339e+05
R_Dense_2_204_4 L1_N204 L2_N4 1.7341613169e+05
R_Dense_2_205_4 L1_N205 L2_N4 2.0602822503e+05
R_Dense_2_206_4 L1_N206 L2_N4 2.7239380211e+05
R_Dense_2_207_4 L1_N207 L2_N4 6.5780865551e+05
R_Dense_2_208_4 L1_N208 L2_N4 3.1939079015e+05
R_Dense_2_209_4 L1_N209 L2_N4 1.9549440728e+05
R_Dense_2_210_4 L1_N210 L2_N4 1.8827749027e+05
R_Dense_2_211_4 L1_N211 L2_N4 1.8079892857e+05
R_Dense_2_212_4 L1_N212 L2_N4 1.4967089965e+05
R_Dense_2_213_4 L1_N213 L2_N4 2.5466771910e+05
R_Dense_2_214_4 L1_N214 L2_N4 1.8365830372e+05
R_Dense_2_215_4 L1_N215 L2_N4 6.2608746416e+05
R_Dense_2_216_4 L1_N216 L2_N4 2.6146491831e+05
R_Dense_2_217_4 L1_N217 L2_N4 1.3516335193e+06
R_Dense_2_218_4 L1_N218 L2_N4 5.0825015189e+06
R_Dense_2_219_4 L1_N219 L2_N4 3.6083602555e+05
R_Dense_2_220_4 L1_N220 L2_N4 1.1381602248e+05
R_Dense_2_221_4 L1_N221 L2_N4 1.3994723295e+05
R_Dense_2_222_4 L1_N222 L2_N4 1.3806494559e+05
R_Dense_2_223_4 L1_N223 L2_N4 1.2675841749e+05
R_Dense_2_224_4 L1_N224 L2_N4 6.2538442424e+05
R_Dense_2_225_4 L1_N225 L2_N4 2.1108019011e+05
R_Dense_2_226_4 L1_N226 L2_N4 1.3860490389e+05
R_Dense_2_227_4 L1_N227 L2_N4 1.7625862397e+05
R_Dense_2_228_4 L1_N228 L2_N4 2.4592274322e+05
R_Dense_2_229_4 L1_N229 L2_N4 1.8796658776e+06
R_Dense_2_230_4 L1_N230 L2_N4 6.3386185806e+05
R_Dense_2_231_4 L1_N231 L2_N4 2.5924439930e+05
R_Dense_2_232_4 L1_N232 L2_N4 1.8312548072e+05
R_Dense_2_233_4 L1_N233 L2_N4 5.8304217919e+05
R_Dense_2_234_4 L1_N234 L2_N4 1.3490919041e+05
R_Dense_2_235_4 L1_N235 L2_N4 2.8518826194e+05
R_Dense_2_236_4 L1_N236 L2_N4 1.0680340683e+05
R_Dense_2_237_4 L1_N237 L2_N4 2.5056864850e+05
R_Dense_2_238_4 L1_N238 L2_N4 1.5317866595e+05
R_Dense_2_239_4 L1_N239 L2_N4 1.4474607197e+05
R_Dense_2_240_4 L1_N240 L2_N4 7.3624791664e+05
R_Dense_2_241_4 L1_N241 L2_N4 2.3174760663e+05
R_Dense_2_242_4 L1_N242 L2_N4 1.1002199711e+05
R_Dense_2_243_4 L1_N243 L2_N4 2.7357232836e+05
R_Dense_2_244_4 L1_N244 L2_N4 1.3419021383e+05
R_Dense_2_245_4 L1_N245 L2_N4 2.0531635508e+05
R_Dense_2_246_4 L1_N246 L2_N4 4.4399041650e+05
R_Dense_2_247_4 L1_N247 L2_N4 1.3047911121e+05
R_Dense_2_248_4 L1_N248 L2_N4 1.1209099119e+06
R_Dense_2_249_4 L1_N249 L2_N4 3.1006844426e+05
R_Dense_2_250_4 L1_N250 L2_N4 1.5766378134e+05
R_Dense_2_251_4 L1_N251 L2_N4 5.1237985968e+05
R_Dense_2_252_4 L1_N252 L2_N4 4.1934475569e+05
R_Dense_2_253_4 L1_N253 L2_N4 1.5370836015e+05
R_Dense_2_254_4 L1_N254 L2_N4 1.5937187071e+05
R_Dense_2_255_4 L1_N255 L2_N4 3.7859212339e+05
R_Dense_2_256_4 L1_N256 L2_N4 1.3256977753e+05
R_Dense_2_257_4 L1_N257 L2_N4 1.4062231197e+06
R_Dense_2_258_4 L1_N258 L2_N4 1.6042826682e+05
R_Dense_2_259_4 L1_N259 L2_N4 2.7070536554e+05
R_Dense_2_260_4 L1_N260 L2_N4 2.2779975722e+05
R_Dense_2_261_4 L1_N261 L2_N4 1.1122847036e+05
R_Dense_2_262_4 L1_N262 L2_N4 1.7305417906e+05
R_Dense_2_263_4 L1_N263 L2_N4 2.1477960147e+05
R_Dense_2_264_4 L1_N264 L2_N4 6.0655677342e+05
R_Dense_2_265_4 L1_N265 L2_N4 5.8514998936e+05
R_Dense_2_266_4 L1_N266 L2_N4 4.7673652914e+05
R_Dense_2_267_4 L1_N267 L2_N4 2.0062272787e+05
R_Dense_2_268_4 L1_N268 L2_N4 1.1941110657e+05
R_Dense_2_269_4 L1_N269 L2_N4 3.5991410885e+05
R_Dense_2_270_4 L1_N270 L2_N4 2.9255652024e+05
R_Dense_2_271_4 L1_N271 L2_N4 1.0169405819e+05
R_Dense_2_272_4 L1_N272 L2_N4 4.3481808809e+05
R_Dense_2_273_4 L1_N273 L2_N4 1.1491489379e+05
R_Dense_2_274_4 L1_N274 L2_N4 1.1844578236e+06
R_Dense_2_275_4 L1_N275 L2_N4 1.0451559231e+05
R_Dense_2_276_4 L1_N276 L2_N4 1.4420304138e+05
R_Dense_2_277_4 L1_N277 L2_N4 1.8623280595e+06
R_Dense_2_278_4 L1_N278 L2_N4 1.5305957195e+06
R_Dense_2_279_4 L1_N279 L2_N4 1.4090392034e+05
R_Dense_2_280_4 L1_N280 L2_N4 1.0700645596e+05
R_Dense_2_281_4 L1_N281 L2_N4 4.1747026029e+05
R_Dense_2_282_4 L1_N282 L2_N4 7.6095292731e+05
R_Dense_2_283_4 L1_N283 L2_N4 1.1956331728e+06
R_Dense_2_284_4 L1_N284 L2_N4 1.1564548775e+05
R_Dense_2_285_4 L1_N285 L2_N4 1.4607783028e+05
R_Dense_2_286_4 L1_N286 L2_N4 1.0173836011e+05
R_Dense_2_287_4 L1_N287 L2_N4 2.0352688204e+05
R_Dense_2_288_4 L1_N288 L2_N4 1.5450404363e+05
R_Dense_2_289_4 L1_N289 L2_N4 1.4660691043e+05
R_Dense_2_290_4 L1_N290 L2_N4 3.5391751946e+05
R_Dense_2_291_4 L1_N291 L2_N4 1.5946228144e+05
R_Dense_2_292_4 L1_N292 L2_N4 1.0579797559e+05
R_Dense_2_293_4 L1_N293 L2_N4 1.2843509898e+05
R_Dense_2_294_4 L1_N294 L2_N4 4.9494588230e+05
R_Dense_2_295_4 L1_N295 L2_N4 2.2466180050e+05
R_Dense_2_296_4 L1_N296 L2_N4 4.3547775635e+05
R_Dense_2_297_4 L1_N297 L2_N4 1.8278211624e+06
R_Dense_2_298_4 L1_N298 L2_N4 2.3485356897e+05
R_Dense_2_299_4 L1_N299 L2_N4 2.4415701345e+06
R_Dense_2_300_4 L1_N300 L2_N4 2.1096923280e+05
R_Dense_2_301_4 L1_N301 L2_N4 1.9310634144e+05
R_Dense_2_302_4 L1_N302 L2_N4 1.4028259285e+05
R_Dense_2_303_4 L1_N303 L2_N4 5.3989287874e+05
R_Dense_2_304_4 L1_N304 L2_N4 9.8185298020e+05
R_Dense_2_305_4 L1_N305 L2_N4 1.9740654954e+05
R_Dense_2_306_4 L1_N306 L2_N4 2.7692920405e+05
R_Dense_2_307_4 L1_N307 L2_N4 2.1828622818e+05
R_Dense_2_308_4 L1_N308 L2_N4 4.6331897545e+05
R_Dense_2_309_4 L1_N309 L2_N4 2.9172019244e+05
R_Dense_2_310_4 L1_N310 L2_N4 3.4982802368e+05
R_Dense_2_311_4 L1_N311 L2_N4 1.0057618716e+05
R_Dense_2_312_4 L1_N312 L2_N4 1.5561772229e+05
R_Dense_2_313_4 L1_N313 L2_N4 1.6717880559e+05
R_Dense_2_314_4 L1_N314 L2_N4 1.9570128499e+05
R_Dense_2_315_4 L1_N315 L2_N4 1.6284765351e+05
R_Dense_2_316_4 L1_N316 L2_N4 1.0106257936e+05
R_Dense_2_317_4 L1_N317 L2_N4 1.2751612995e+05
R_Dense_2_318_4 L1_N318 L2_N4 1.1371231340e+05
R_Dense_2_319_4 L1_N319 L2_N4 4.5692588988e+06
R_Dense_2_320_4 L1_N320 L2_N4 2.3420538436e+06
R_Dense_2_321_4 L1_N321 L2_N4 1.0475904796e+05
R_Dense_2_322_4 L1_N322 L2_N4 1.0677654851e+05
R_Dense_2_323_4 L1_N323 L2_N4 1.0151283321e+05
R_Dense_2_324_4 L1_N324 L2_N4 3.8307238962e+05
R_Dense_2_325_4 L1_N325 L2_N4 1.8453385730e+06
R_Dense_2_326_4 L1_N326 L2_N4 5.0073851062e+05
R_Dense_2_327_4 L1_N327 L2_N4 5.4730361425e+05
R_Dense_2_328_4 L1_N328 L2_N4 1.6640891587e+06
R_Dense_2_329_4 L1_N329 L2_N4 1.3582061381e+05
R_Dense_2_330_4 L1_N330 L2_N4 1.2203477059e+05
R_Dense_2_331_4 L1_N331 L2_N4 1.2939433820e+05
R_Dense_2_332_4 L1_N332 L2_N4 1.0356878331e+05
R_Dense_2_333_4 L1_N333 L2_N4 1.1931642980e+05
R_Dense_2_334_4 L1_N334 L2_N4 1.3221940452e+05
R_Dense_2_335_4 L1_N335 L2_N4 1.3379810197e+05
R_Dense_2_336_4 L1_N336 L2_N4 2.1863925539e+05
R_Dense_2_337_4 L1_N337 L2_N4 1.7426241613e+05
*
R_Dense_2_0_5 L1_N0 L2_N5 9.8131713927e+05
R_Dense_2_1_5 L1_N1 L2_N5 1.5927493115e+05
R_Dense_2_2_5 L1_N2 L2_N5 2.0744005244e+05
R_Dense_2_3_5 L1_N3 L2_N5 2.9649688040e+05
R_Dense_2_4_5 L1_N4 L2_N5 1.8952466537e+05
R_Dense_2_5_5 L1_N5 L2_N5 1.7018337995e+05
R_Dense_2_6_5 L1_N6 L2_N5 2.5677688180e+05
R_Dense_2_7_5 L1_N7 L2_N5 2.1209663244e+05
R_Dense_2_8_5 L1_N8 L2_N5 1.1634245164e+05
R_Dense_2_9_5 L1_N9 L2_N5 1.6519152543e+05
R_Dense_2_10_5 L1_N10 L2_N5 1.2359703741e+05
R_Dense_2_11_5 L1_N11 L2_N5 7.2437699013e+05
R_Dense_2_12_5 L1_N12 L2_N5 1.1704121109e+05
R_Dense_2_13_5 L1_N13 L2_N5 1.0818731721e+05
R_Dense_2_14_5 L1_N14 L2_N5 1.2626104079e+05
R_Dense_2_15_5 L1_N15 L2_N5 1.1329926643e+05
R_Dense_2_16_5 L1_N16 L2_N5 1.8888823095e+05
R_Dense_2_17_5 L1_N17 L2_N5 1.3237968301e+05
R_Dense_2_18_5 L1_N18 L2_N5 1.2657132813e+05
R_Dense_2_19_5 L1_N19 L2_N5 2.4658229577e+05
R_Dense_2_20_5 L1_N20 L2_N5 1.1527799277e+05
R_Dense_2_21_5 L1_N21 L2_N5 1.1406665479e+05
R_Dense_2_22_5 L1_N22 L2_N5 1.0166678981e+05
R_Dense_2_23_5 L1_N23 L2_N5 2.6825781269e+05
R_Dense_2_24_5 L1_N24 L2_N5 1.6054954867e+06
R_Dense_2_25_5 L1_N25 L2_N5 8.7541508152e+05
R_Dense_2_26_5 L1_N26 L2_N5 2.0330060615e+05
R_Dense_2_27_5 L1_N27 L2_N5 1.1621439555e+05
R_Dense_2_28_5 L1_N28 L2_N5 4.4622804168e+05
R_Dense_2_29_5 L1_N29 L2_N5 1.7767950070e+05
R_Dense_2_30_5 L1_N30 L2_N5 1.3703071496e+05
R_Dense_2_31_5 L1_N31 L2_N5 1.2222546097e+05
R_Dense_2_32_5 L1_N32 L2_N5 1.3193532095e+05
R_Dense_2_33_5 L1_N33 L2_N5 2.3313692912e+05
R_Dense_2_34_5 L1_N34 L2_N5 1.4448139827e+05
R_Dense_2_35_5 L1_N35 L2_N5 2.1671032858e+05
R_Dense_2_36_5 L1_N36 L2_N5 1.0787794964e+05
R_Dense_2_37_5 L1_N37 L2_N5 1.1896248544e+05
R_Dense_2_38_5 L1_N38 L2_N5 1.0043952349e+05
R_Dense_2_39_5 L1_N39 L2_N5 4.3083321248e+05
R_Dense_2_40_5 L1_N40 L2_N5 2.0784094238e+05
R_Dense_2_41_5 L1_N41 L2_N5 1.0434113383e+05
R_Dense_2_42_5 L1_N42 L2_N5 1.9923496431e+05
R_Dense_2_43_5 L1_N43 L2_N5 5.0024788007e+05
R_Dense_2_44_5 L1_N44 L2_N5 1.0829556171e+05
R_Dense_2_45_5 L1_N45 L2_N5 1.0182457862e+05
R_Dense_2_46_5 L1_N46 L2_N5 4.3549662773e+06
R_Dense_2_47_5 L1_N47 L2_N5 2.9528799864e+05
R_Dense_2_48_5 L1_N48 L2_N5 5.6903036087e+05
R_Dense_2_49_5 L1_N49 L2_N5 2.9403723035e+05
R_Dense_2_50_5 L1_N50 L2_N5 1.8974722092e+05
R_Dense_2_51_5 L1_N51 L2_N5 2.2196588550e+05
R_Dense_2_52_5 L1_N52 L2_N5 1.1415349560e+05
R_Dense_2_53_5 L1_N53 L2_N5 1.8953639924e+05
R_Dense_2_54_5 L1_N54 L2_N5 1.5476126590e+05
R_Dense_2_55_5 L1_N55 L2_N5 1.5199826120e+05
R_Dense_2_56_5 L1_N56 L2_N5 1.1725397408e+05
R_Dense_2_57_5 L1_N57 L2_N5 8.4251963008e+05
R_Dense_2_58_5 L1_N58 L2_N5 1.4378858031e+05
R_Dense_2_59_5 L1_N59 L2_N5 1.4048768963e+05
R_Dense_2_60_5 L1_N60 L2_N5 1.0556604836e+05
R_Dense_2_61_5 L1_N61 L2_N5 1.3826728529e+05
R_Dense_2_62_5 L1_N62 L2_N5 2.1203883646e+05
R_Dense_2_63_5 L1_N63 L2_N5 2.9750479876e+05
R_Dense_2_64_5 L1_N64 L2_N5 3.2064339589e+05
R_Dense_2_65_5 L1_N65 L2_N5 1.3587814444e+05
R_Dense_2_66_5 L1_N66 L2_N5 5.8390856530e+05
R_Dense_2_67_5 L1_N67 L2_N5 1.2472322538e+06
R_Dense_2_68_5 L1_N68 L2_N5 5.6349308249e+05
R_Dense_2_69_5 L1_N69 L2_N5 7.5918359868e+05
R_Dense_2_70_5 L1_N70 L2_N5 4.3313734589e+05
R_Dense_2_71_5 L1_N71 L2_N5 1.0142268278e+05
R_Dense_2_72_5 L1_N72 L2_N5 1.3559825944e+05
R_Dense_2_73_5 L1_N73 L2_N5 3.8412816993e+05
R_Dense_2_74_5 L1_N74 L2_N5 2.7976721497e+05
R_Dense_2_75_5 L1_N75 L2_N5 2.3578703830e+05
R_Dense_2_76_5 L1_N76 L2_N5 4.0794853358e+05
R_Dense_2_77_5 L1_N77 L2_N5 1.5537110232e+05
R_Dense_2_78_5 L1_N78 L2_N5 1.6066094138e+05
R_Dense_2_79_5 L1_N79 L2_N5 1.6633599351e+05
R_Dense_2_80_5 L1_N80 L2_N5 1.4139934157e+05
R_Dense_2_81_5 L1_N81 L2_N5 2.1894443397e+05
R_Dense_2_82_5 L1_N82 L2_N5 1.6726644022e+05
R_Dense_2_83_5 L1_N83 L2_N5 8.7592096011e+05
R_Dense_2_84_5 L1_N84 L2_N5 1.3389865516e+05
R_Dense_2_85_5 L1_N85 L2_N5 5.2919087550e+06
R_Dense_2_86_5 L1_N86 L2_N5 7.3545543371e+05
R_Dense_2_87_5 L1_N87 L2_N5 1.8515714414e+05
R_Dense_2_88_5 L1_N88 L2_N5 3.1687820861e+05
R_Dense_2_89_5 L1_N89 L2_N5 1.7150955630e+05
R_Dense_2_90_5 L1_N90 L2_N5 1.4617561982e+05
R_Dense_2_91_5 L1_N91 L2_N5 1.2505271476e+05
R_Dense_2_92_5 L1_N92 L2_N5 1.3095150429e+05
R_Dense_2_93_5 L1_N93 L2_N5 2.6852969797e+05
R_Dense_2_94_5 L1_N94 L2_N5 2.4655828700e+05
R_Dense_2_95_5 L1_N95 L2_N5 2.7921972228e+05
R_Dense_2_96_5 L1_N96 L2_N5 2.0951840546e+05
R_Dense_2_97_5 L1_N97 L2_N5 2.8984469433e+05
R_Dense_2_98_5 L1_N98 L2_N5 5.8720024609e+05
R_Dense_2_99_5 L1_N99 L2_N5 4.9747721143e+05
R_Dense_2_100_5 L1_N100 L2_N5 1.5205186401e+05
R_Dense_2_101_5 L1_N101 L2_N5 1.2803421744e+05
R_Dense_2_102_5 L1_N102 L2_N5 4.6846034781e+05
R_Dense_2_103_5 L1_N103 L2_N5 1.5009843194e+06
R_Dense_2_104_5 L1_N104 L2_N5 1.0610407212e+05
R_Dense_2_105_5 L1_N105 L2_N5 1.1103332274e+05
R_Dense_2_106_5 L1_N106 L2_N5 1.2953665712e+05
R_Dense_2_107_5 L1_N107 L2_N5 1.5142351665e+05
R_Dense_2_108_5 L1_N108 L2_N5 1.2887146468e+05
R_Dense_2_109_5 L1_N109 L2_N5 1.5847980773e+05
R_Dense_2_110_5 L1_N110 L2_N5 1.6935502604e+05
R_Dense_2_111_5 L1_N111 L2_N5 1.0227895509e+05
R_Dense_2_112_5 L1_N112 L2_N5 1.8216755574e+05
R_Dense_2_113_5 L1_N113 L2_N5 6.5054818916e+05
R_Dense_2_114_5 L1_N114 L2_N5 2.7148317813e+05
R_Dense_2_115_5 L1_N115 L2_N5 3.3913324622e+05
R_Dense_2_116_5 L1_N116 L2_N5 2.0651020518e+05
R_Dense_2_117_5 L1_N117 L2_N5 4.3973443434e+05
R_Dense_2_118_5 L1_N118 L2_N5 6.5162109360e+05
R_Dense_2_119_5 L1_N119 L2_N5 1.4290056984e+05
R_Dense_2_120_5 L1_N120 L2_N5 1.1669234109e+05
R_Dense_2_121_5 L1_N121 L2_N5 1.6503022862e+05
R_Dense_2_122_5 L1_N122 L2_N5 1.2164649619e+05
R_Dense_2_123_5 L1_N123 L2_N5 1.4968713000e+05
R_Dense_2_124_5 L1_N124 L2_N5 1.8909867830e+05
R_Dense_2_125_5 L1_N125 L2_N5 4.1656319199e+05
R_Dense_2_126_5 L1_N126 L2_N5 1.4705840717e+05
R_Dense_2_127_5 L1_N127 L2_N5 1.0134456850e+06
R_Dense_2_128_5 L1_N128 L2_N5 1.3191281924e+05
R_Dense_2_129_5 L1_N129 L2_N5 2.2326729222e+05
R_Dense_2_130_5 L1_N130 L2_N5 1.9442204148e+05
R_Dense_2_131_5 L1_N131 L2_N5 1.4771869131e+05
R_Dense_2_132_5 L1_N132 L2_N5 2.0402812845e+05
R_Dense_2_133_5 L1_N133 L2_N5 2.1393235420e+05
R_Dense_2_134_5 L1_N134 L2_N5 2.0867124788e+05
R_Dense_2_135_5 L1_N135 L2_N5 2.1875723199e+05
R_Dense_2_136_5 L1_N136 L2_N5 2.2673811326e+05
R_Dense_2_137_5 L1_N137 L2_N5 1.5990701657e+05
R_Dense_2_138_5 L1_N138 L2_N5 4.7054039924e+06
R_Dense_2_139_5 L1_N139 L2_N5 1.4571034504e+05
R_Dense_2_140_5 L1_N140 L2_N5 1.4385871566e+05
R_Dense_2_141_5 L1_N141 L2_N5 2.2105995909e+05
R_Dense_2_142_5 L1_N142 L2_N5 1.6476550182e+05
R_Dense_2_143_5 L1_N143 L2_N5 1.9332074828e+05
R_Dense_2_144_5 L1_N144 L2_N5 1.7065325854e+05
R_Dense_2_145_5 L1_N145 L2_N5 1.7855814707e+05
R_Dense_2_146_5 L1_N146 L2_N5 9.0065041318e+05
R_Dense_2_147_5 L1_N147 L2_N5 1.0459018788e+05
R_Dense_2_148_5 L1_N148 L2_N5 1.0675019962e+05
R_Dense_2_149_5 L1_N149 L2_N5 1.5296650401e+05
R_Dense_2_150_5 L1_N150 L2_N5 3.4843313037e+05
R_Dense_2_151_5 L1_N151 L2_N5 7.3791017684e+05
R_Dense_2_152_5 L1_N152 L2_N5 2.9822894955e+05
R_Dense_2_153_5 L1_N153 L2_N5 1.3858248772e+05
R_Dense_2_154_5 L1_N154 L2_N5 1.1081075077e+05
R_Dense_2_155_5 L1_N155 L2_N5 1.8590263964e+05
R_Dense_2_156_5 L1_N156 L2_N5 1.8260530371e+05
R_Dense_2_157_5 L1_N157 L2_N5 1.2462653819e+05
R_Dense_2_158_5 L1_N158 L2_N5 1.7400298797e+05
R_Dense_2_159_5 L1_N159 L2_N5 4.4398325249e+05
R_Dense_2_160_5 L1_N160 L2_N5 1.8975658583e+05
R_Dense_2_161_5 L1_N161 L2_N5 1.1772932316e+05
R_Dense_2_162_5 L1_N162 L2_N5 1.2022985941e+05
R_Dense_2_163_5 L1_N163 L2_N5 3.7850353457e+05
R_Dense_2_164_5 L1_N164 L2_N5 4.2460026440e+06
R_Dense_2_165_5 L1_N165 L2_N5 1.0077656279e+05
R_Dense_2_166_5 L1_N166 L2_N5 3.0299814228e+05
R_Dense_2_167_5 L1_N167 L2_N5 1.7555839964e+05
R_Dense_2_168_5 L1_N168 L2_N5 1.0086700544e+05
R_Dense_2_169_5 L1_N169 L2_N5 6.6262817582e+05
R_Dense_2_170_5 L1_N170 L2_N5 2.2621312369e+05
R_Dense_2_171_5 L1_N171 L2_N5 3.7360624653e+05
R_Dense_2_172_5 L1_N172 L2_N5 2.3387100694e+05
R_Dense_2_173_5 L1_N173 L2_N5 1.4158105659e+05
R_Dense_2_174_5 L1_N174 L2_N5 9.1106538373e+05
R_Dense_2_175_5 L1_N175 L2_N5 5.1886546947e+05
R_Dense_2_176_5 L1_N176 L2_N5 2.8454161102e+05
R_Dense_2_177_5 L1_N177 L2_N5 1.1982908915e+05
R_Dense_2_178_5 L1_N178 L2_N5 1.8697439256e+05
R_Dense_2_179_5 L1_N179 L2_N5 2.4081176585e+05
R_Dense_2_180_5 L1_N180 L2_N5 8.4414269118e+05
R_Dense_2_181_5 L1_N181 L2_N5 2.3676862648e+05
R_Dense_2_182_5 L1_N182 L2_N5 2.2024402784e+05
R_Dense_2_183_5 L1_N183 L2_N5 1.3644005997e+05
R_Dense_2_184_5 L1_N184 L2_N5 1.3438707969e+06
R_Dense_2_185_5 L1_N185 L2_N5 4.7417032563e+06
R_Dense_2_186_5 L1_N186 L2_N5 3.4197697588e+05
R_Dense_2_187_5 L1_N187 L2_N5 1.0989664508e+05
R_Dense_2_188_5 L1_N188 L2_N5 5.3634965964e+05
R_Dense_2_189_5 L1_N189 L2_N5 1.0923614377e+05
R_Dense_2_190_5 L1_N190 L2_N5 3.9027428392e+05
R_Dense_2_191_5 L1_N191 L2_N5 1.0411051550e+05
R_Dense_2_192_5 L1_N192 L2_N5 1.8326850492e+06
R_Dense_2_193_5 L1_N193 L2_N5 1.4285693051e+05
R_Dense_2_194_5 L1_N194 L2_N5 2.9927038784e+05
R_Dense_2_195_5 L1_N195 L2_N5 4.5314600143e+06
R_Dense_2_196_5 L1_N196 L2_N5 1.6952073112e+05
R_Dense_2_197_5 L1_N197 L2_N5 3.0209059911e+05
R_Dense_2_198_5 L1_N198 L2_N5 1.1308270185e+05
R_Dense_2_199_5 L1_N199 L2_N5 2.7708238928e+05
R_Dense_2_200_5 L1_N200 L2_N5 1.4084193475e+05
R_Dense_2_201_5 L1_N201 L2_N5 1.0307214003e+05
R_Dense_2_202_5 L1_N202 L2_N5 1.9474844508e+05
R_Dense_2_203_5 L1_N203 L2_N5 1.1645305589e+05
R_Dense_2_204_5 L1_N204 L2_N5 1.0758975799e+05
R_Dense_2_205_5 L1_N205 L2_N5 1.0700941476e+05
R_Dense_2_206_5 L1_N206 L2_N5 2.2361952532e+05
R_Dense_2_207_5 L1_N207 L2_N5 3.6178862906e+05
R_Dense_2_208_5 L1_N208 L2_N5 1.6295105558e+05
R_Dense_2_209_5 L1_N209 L2_N5 1.7669781994e+05
R_Dense_2_210_5 L1_N210 L2_N5 2.8316147115e+05
R_Dense_2_211_5 L1_N211 L2_N5 1.4390576793e+06
R_Dense_2_212_5 L1_N212 L2_N5 1.5134800286e+05
R_Dense_2_213_5 L1_N213 L2_N5 1.7440257804e+05
R_Dense_2_214_5 L1_N214 L2_N5 1.3550709626e+05
R_Dense_2_215_5 L1_N215 L2_N5 1.3365187457e+05
R_Dense_2_216_5 L1_N216 L2_N5 1.5711316814e+05
R_Dense_2_217_5 L1_N217 L2_N5 1.1885736268e+05
R_Dense_2_218_5 L1_N218 L2_N5 2.5796317102e+05
R_Dense_2_219_5 L1_N219 L2_N5 2.0464620998e+05
R_Dense_2_220_5 L1_N220 L2_N5 1.1897048141e+05
R_Dense_2_221_5 L1_N221 L2_N5 2.1164839781e+05
R_Dense_2_222_5 L1_N222 L2_N5 2.6528279216e+05
R_Dense_2_223_5 L1_N223 L2_N5 2.2782253516e+05
R_Dense_2_224_5 L1_N224 L2_N5 1.0258656622e+05
R_Dense_2_225_5 L1_N225 L2_N5 5.1059315893e+05
R_Dense_2_226_5 L1_N226 L2_N5 2.4676645938e+05
R_Dense_2_227_5 L1_N227 L2_N5 2.0201292452e+05
R_Dense_2_228_5 L1_N228 L2_N5 2.1099420969e+05
R_Dense_2_229_5 L1_N229 L2_N5 3.0819145441e+06
R_Dense_2_230_5 L1_N230 L2_N5 1.9756895427e+05
R_Dense_2_231_5 L1_N231 L2_N5 7.9356136916e+05
R_Dense_2_232_5 L1_N232 L2_N5 1.4121860718e+05
R_Dense_2_233_5 L1_N233 L2_N5 2.7064830410e+05
R_Dense_2_234_5 L1_N234 L2_N5 1.8560906031e+05
R_Dense_2_235_5 L1_N235 L2_N5 2.0094080823e+05
R_Dense_2_236_5 L1_N236 L2_N5 3.4128038016e+05
R_Dense_2_237_5 L1_N237 L2_N5 1.8958419573e+05
R_Dense_2_238_5 L1_N238 L2_N5 1.0881783321e+05
R_Dense_2_239_5 L1_N239 L2_N5 1.0804467033e+06
R_Dense_2_240_5 L1_N240 L2_N5 4.5717212086e+06
R_Dense_2_241_5 L1_N241 L2_N5 2.4703007861e+05
R_Dense_2_242_5 L1_N242 L2_N5 1.7500189480e+05
R_Dense_2_243_5 L1_N243 L2_N5 6.0754265383e+05
R_Dense_2_244_5 L1_N244 L2_N5 1.4976672713e+05
R_Dense_2_245_5 L1_N245 L2_N5 2.5395837625e+05
R_Dense_2_246_5 L1_N246 L2_N5 3.0081538339e+05
R_Dense_2_247_5 L1_N247 L2_N5 2.3090707279e+05
R_Dense_2_248_5 L1_N248 L2_N5 2.8353366120e+05
R_Dense_2_249_5 L1_N249 L2_N5 2.0206894810e+05
R_Dense_2_250_5 L1_N250 L2_N5 1.2319044541e+05
R_Dense_2_251_5 L1_N251 L2_N5 2.0968988339e+05
R_Dense_2_252_5 L1_N252 L2_N5 1.1629616612e+05
R_Dense_2_253_5 L1_N253 L2_N5 1.4526990019e+05
R_Dense_2_254_5 L1_N254 L2_N5 1.9713727791e+05
R_Dense_2_255_5 L1_N255 L2_N5 1.9576774970e+05
R_Dense_2_256_5 L1_N256 L2_N5 4.9699698071e+05
R_Dense_2_257_5 L1_N257 L2_N5 1.0492860806e+05
R_Dense_2_258_5 L1_N258 L2_N5 1.0704939555e+05
R_Dense_2_259_5 L1_N259 L2_N5 4.7629190724e+05
R_Dense_2_260_5 L1_N260 L2_N5 1.5217985016e+05
R_Dense_2_261_5 L1_N261 L2_N5 1.9798990185e+05
R_Dense_2_262_5 L1_N262 L2_N5 1.4598546830e+05
R_Dense_2_263_5 L1_N263 L2_N5 1.4470267272e+05
R_Dense_2_264_5 L1_N264 L2_N5 2.4601238884e+05
R_Dense_2_265_5 L1_N265 L2_N5 1.6723758418e+05
R_Dense_2_266_5 L1_N266 L2_N5 1.4332274911e+05
R_Dense_2_267_5 L1_N267 L2_N5 6.6399106029e+05
R_Dense_2_268_5 L1_N268 L2_N5 2.1428677459e+05
R_Dense_2_269_5 L1_N269 L2_N5 2.1717492348e+05
R_Dense_2_270_5 L1_N270 L2_N5 5.5389609223e+05
R_Dense_2_271_5 L1_N271 L2_N5 1.1071171021e+05
R_Dense_2_272_5 L1_N272 L2_N5 6.2674051452e+05
R_Dense_2_273_5 L1_N273 L2_N5 1.9763979403e+05
R_Dense_2_274_5 L1_N274 L2_N5 1.5123093387e+05
R_Dense_2_275_5 L1_N275 L2_N5 2.7455072915e+05
R_Dense_2_276_5 L1_N276 L2_N5 1.3666769981e+05
R_Dense_2_277_5 L1_N277 L2_N5 1.1855555242e+05
R_Dense_2_278_5 L1_N278 L2_N5 1.0949228307e+05
R_Dense_2_279_5 L1_N279 L2_N5 1.7698965209e+05
R_Dense_2_280_5 L1_N280 L2_N5 5.9488766216e+05
R_Dense_2_281_5 L1_N281 L2_N5 1.8235565375e+05
R_Dense_2_282_5 L1_N282 L2_N5 1.2524442569e+05
R_Dense_2_283_5 L1_N283 L2_N5 1.3392500685e+05
R_Dense_2_284_5 L1_N284 L2_N5 1.2789650502e+05
R_Dense_2_285_5 L1_N285 L2_N5 2.6832534816e+05
R_Dense_2_286_5 L1_N286 L2_N5 3.7407293902e+05
R_Dense_2_287_5 L1_N287 L2_N5 1.3457089339e+06
R_Dense_2_288_5 L1_N288 L2_N5 4.0095579195e+05
R_Dense_2_289_5 L1_N289 L2_N5 4.2095502681e+05
R_Dense_2_290_5 L1_N290 L2_N5 1.8775435943e+05
R_Dense_2_291_5 L1_N291 L2_N5 1.0457717118e+05
R_Dense_2_292_5 L1_N292 L2_N5 1.4089650176e+05
R_Dense_2_293_5 L1_N293 L2_N5 3.4288302076e+05
R_Dense_2_294_5 L1_N294 L2_N5 1.1590963892e+05
R_Dense_2_295_5 L1_N295 L2_N5 1.6464055398e+05
R_Dense_2_296_5 L1_N296 L2_N5 1.3973835749e+05
R_Dense_2_297_5 L1_N297 L2_N5 1.2301514958e+05
R_Dense_2_298_5 L1_N298 L2_N5 1.3160122151e+05
R_Dense_2_299_5 L1_N299 L2_N5 1.9605003192e+05
R_Dense_2_300_5 L1_N300 L2_N5 4.9576217166e+05
R_Dense_2_301_5 L1_N301 L2_N5 1.5053652341e+06
R_Dense_2_302_5 L1_N302 L2_N5 1.9101676726e+05
R_Dense_2_303_5 L1_N303 L2_N5 2.3112071904e+05
R_Dense_2_304_5 L1_N304 L2_N5 1.1131514773e+05
R_Dense_2_305_5 L1_N305 L2_N5 1.3992191580e+05
R_Dense_2_306_5 L1_N306 L2_N5 1.4667894592e+05
R_Dense_2_307_5 L1_N307 L2_N5 5.4148555084e+05
R_Dense_2_308_5 L1_N308 L2_N5 1.5217158252e+05
R_Dense_2_309_5 L1_N309 L2_N5 8.8931667498e+05
R_Dense_2_310_5 L1_N310 L2_N5 1.2457652909e+05
R_Dense_2_311_5 L1_N311 L2_N5 1.4673406667e+05
R_Dense_2_312_5 L1_N312 L2_N5 6.4103077050e+06
R_Dense_2_313_5 L1_N313 L2_N5 2.2243336407e+05
R_Dense_2_314_5 L1_N314 L2_N5 1.9120039836e+05
R_Dense_2_315_5 L1_N315 L2_N5 1.0494423734e+05
R_Dense_2_316_5 L1_N316 L2_N5 2.3004778798e+05
R_Dense_2_317_5 L1_N317 L2_N5 3.0439285509e+05
R_Dense_2_318_5 L1_N318 L2_N5 1.2395619218e+05
R_Dense_2_319_5 L1_N319 L2_N5 7.5313702259e+05
R_Dense_2_320_5 L1_N320 L2_N5 5.1352406928e+05
R_Dense_2_321_5 L1_N321 L2_N5 1.0205542309e+05
R_Dense_2_322_5 L1_N322 L2_N5 1.4622147171e+05
R_Dense_2_323_5 L1_N323 L2_N5 1.9647052109e+05
R_Dense_2_324_5 L1_N324 L2_N5 1.1496904110e+05
R_Dense_2_325_5 L1_N325 L2_N5 7.3759997731e+05
R_Dense_2_326_5 L1_N326 L2_N5 4.4326064340e+05
R_Dense_2_327_5 L1_N327 L2_N5 3.3293436084e+06
R_Dense_2_328_5 L1_N328 L2_N5 1.8601238197e+05
R_Dense_2_329_5 L1_N329 L2_N5 2.8809369350e+05
R_Dense_2_330_5 L1_N330 L2_N5 1.3556309598e+06
R_Dense_2_331_5 L1_N331 L2_N5 1.2093062791e+05
R_Dense_2_332_5 L1_N332 L2_N5 1.9758851496e+05
R_Dense_2_333_5 L1_N333 L2_N5 2.6260831903e+05
R_Dense_2_334_5 L1_N334 L2_N5 1.4434254639e+05
R_Dense_2_335_5 L1_N335 L2_N5 2.3159042378e+06
R_Dense_2_336_5 L1_N336 L2_N5 1.3784847796e+05
R_Dense_2_337_5 L1_N337 L2_N5 1.1942720321e+05
*
R_Dense_2_0_6 L1_N0 L2_N6 1.0444556559e+05
R_Dense_2_1_6 L1_N1 L2_N6 1.2346592341e+05
R_Dense_2_2_6 L1_N2 L2_N6 1.2584772670e+05
R_Dense_2_3_6 L1_N3 L2_N6 1.5023355679e+05
R_Dense_2_4_6 L1_N4 L2_N6 1.4617932940e+05
R_Dense_2_5_6 L1_N5 L2_N6 1.1946044366e+05
R_Dense_2_6_6 L1_N6 L2_N6 2.3782993861e+06
R_Dense_2_7_6 L1_N7 L2_N6 7.2506585719e+05
R_Dense_2_8_6 L1_N8 L2_N6 2.6447640602e+05
R_Dense_2_9_6 L1_N9 L2_N6 1.2194650028e+05
R_Dense_2_10_6 L1_N10 L2_N6 2.7645354181e+05
R_Dense_2_11_6 L1_N11 L2_N6 2.2286359394e+05
R_Dense_2_12_6 L1_N12 L2_N6 2.7671475564e+05
R_Dense_2_13_6 L1_N13 L2_N6 1.0228615882e+05
R_Dense_2_14_6 L1_N14 L2_N6 1.0234673125e+05
R_Dense_2_15_6 L1_N15 L2_N6 1.1171423465e+05
R_Dense_2_16_6 L1_N16 L2_N6 1.9120838262e+05
R_Dense_2_17_6 L1_N17 L2_N6 1.3178942450e+05
R_Dense_2_18_6 L1_N18 L2_N6 1.1655823830e+06
R_Dense_2_19_6 L1_N19 L2_N6 1.9483723562e+05
R_Dense_2_20_6 L1_N20 L2_N6 1.7998579487e+05
R_Dense_2_21_6 L1_N21 L2_N6 2.1436575580e+05
R_Dense_2_22_6 L1_N22 L2_N6 1.6767168155e+05
R_Dense_2_23_6 L1_N23 L2_N6 4.1156147456e+05
R_Dense_2_24_6 L1_N24 L2_N6 4.0246714787e+05
R_Dense_2_25_6 L1_N25 L2_N6 2.2351894400e+05
R_Dense_2_26_6 L1_N26 L2_N6 3.4698997701e+05
R_Dense_2_27_6 L1_N27 L2_N6 5.1627860407e+05
R_Dense_2_28_6 L1_N28 L2_N6 2.2466684768e+05
R_Dense_2_29_6 L1_N29 L2_N6 2.1466074673e+05
R_Dense_2_30_6 L1_N30 L2_N6 1.3752824750e+05
R_Dense_2_31_6 L1_N31 L2_N6 3.1766489973e+05
R_Dense_2_32_6 L1_N32 L2_N6 1.7750959600e+05
R_Dense_2_33_6 L1_N33 L2_N6 2.3137207414e+05
R_Dense_2_34_6 L1_N34 L2_N6 1.0662109891e+05
R_Dense_2_35_6 L1_N35 L2_N6 1.3032739600e+05
R_Dense_2_36_6 L1_N36 L2_N6 2.2949268931e+05
R_Dense_2_37_6 L1_N37 L2_N6 1.6887249620e+05
R_Dense_2_38_6 L1_N38 L2_N6 1.2251647807e+05
R_Dense_2_39_6 L1_N39 L2_N6 7.2618093480e+05
R_Dense_2_40_6 L1_N40 L2_N6 1.8651048311e+05
R_Dense_2_41_6 L1_N41 L2_N6 1.8713118190e+05
R_Dense_2_42_6 L1_N42 L2_N6 1.8733925258e+05
R_Dense_2_43_6 L1_N43 L2_N6 1.2634343087e+06
R_Dense_2_44_6 L1_N44 L2_N6 1.7131145161e+05
R_Dense_2_45_6 L1_N45 L2_N6 3.6040998761e+05
R_Dense_2_46_6 L1_N46 L2_N6 1.5090457080e+05
R_Dense_2_47_6 L1_N47 L2_N6 1.3990473091e+06
R_Dense_2_48_6 L1_N48 L2_N6 2.0931561014e+05
R_Dense_2_49_6 L1_N49 L2_N6 1.5945517910e+05
R_Dense_2_50_6 L1_N50 L2_N6 2.5506275687e+05
R_Dense_2_51_6 L1_N51 L2_N6 1.1201107064e+05
R_Dense_2_52_6 L1_N52 L2_N6 3.5355367637e+05
R_Dense_2_53_6 L1_N53 L2_N6 1.0909541119e+05
R_Dense_2_54_6 L1_N54 L2_N6 3.2417622855e+05
R_Dense_2_55_6 L1_N55 L2_N6 1.3901474922e+05
R_Dense_2_56_6 L1_N56 L2_N6 1.5662530947e+05
R_Dense_2_57_6 L1_N57 L2_N6 1.0268082969e+05
R_Dense_2_58_6 L1_N58 L2_N6 1.2638677466e+05
R_Dense_2_59_6 L1_N59 L2_N6 1.5493314313e+05
R_Dense_2_60_6 L1_N60 L2_N6 1.0662994567e+05
R_Dense_2_61_6 L1_N61 L2_N6 1.1008019230e+05
R_Dense_2_62_6 L1_N62 L2_N6 3.4013139758e+05
R_Dense_2_63_6 L1_N63 L2_N6 3.4961348249e+05
R_Dense_2_64_6 L1_N64 L2_N6 4.6747112377e+05
R_Dense_2_65_6 L1_N65 L2_N6 4.3265248644e+05
R_Dense_2_66_6 L1_N66 L2_N6 1.5161882450e+05
R_Dense_2_67_6 L1_N67 L2_N6 3.7956724468e+05
R_Dense_2_68_6 L1_N68 L2_N6 1.7627411037e+06
R_Dense_2_69_6 L1_N69 L2_N6 1.5535999127e+05
R_Dense_2_70_6 L1_N70 L2_N6 1.9424134915e+05
R_Dense_2_71_6 L1_N71 L2_N6 3.5061849989e+05
R_Dense_2_72_6 L1_N72 L2_N6 2.0036045261e+05
R_Dense_2_73_6 L1_N73 L2_N6 1.8697187723e+05
R_Dense_2_74_6 L1_N74 L2_N6 1.5560367644e+05
R_Dense_2_75_6 L1_N75 L2_N6 1.6882639758e+05
R_Dense_2_76_6 L1_N76 L2_N6 2.8803091296e+05
R_Dense_2_77_6 L1_N77 L2_N6 1.6389280775e+05
R_Dense_2_78_6 L1_N78 L2_N6 1.2662393242e+05
R_Dense_2_79_6 L1_N79 L2_N6 1.5840896729e+05
R_Dense_2_80_6 L1_N80 L2_N6 1.0107141945e+05
R_Dense_2_81_6 L1_N81 L2_N6 6.7988594125e+05
R_Dense_2_82_6 L1_N82 L2_N6 8.7334259513e+05
R_Dense_2_83_6 L1_N83 L2_N6 1.0671828014e+05
R_Dense_2_84_6 L1_N84 L2_N6 1.3054725355e+05
R_Dense_2_85_6 L1_N85 L2_N6 1.1233784558e+05
R_Dense_2_86_6 L1_N86 L2_N6 2.6408961028e+05
R_Dense_2_87_6 L1_N87 L2_N6 1.6896606638e+05
R_Dense_2_88_6 L1_N88 L2_N6 1.1020912133e+05
R_Dense_2_89_6 L1_N89 L2_N6 1.5141181237e+05
R_Dense_2_90_6 L1_N90 L2_N6 1.8802198466e+05
R_Dense_2_91_6 L1_N91 L2_N6 1.3635911088e+05
R_Dense_2_92_6 L1_N92 L2_N6 1.2266397206e+05
R_Dense_2_93_6 L1_N93 L2_N6 7.9924485390e+05
R_Dense_2_94_6 L1_N94 L2_N6 1.2047354442e+05
R_Dense_2_95_6 L1_N95 L2_N6 3.7662861129e+05
R_Dense_2_96_6 L1_N96 L2_N6 1.1340324239e+05
R_Dense_2_97_6 L1_N97 L2_N6 6.6588397105e+05
R_Dense_2_98_6 L1_N98 L2_N6 1.6129192537e+05
R_Dense_2_99_6 L1_N99 L2_N6 2.6654913164e+05
R_Dense_2_100_6 L1_N100 L2_N6 2.1491239631e+05
R_Dense_2_101_6 L1_N101 L2_N6 4.1761467717e+05
R_Dense_2_102_6 L1_N102 L2_N6 1.3895782458e+06
R_Dense_2_103_6 L1_N103 L2_N6 5.7278793138e+05
R_Dense_2_104_6 L1_N104 L2_N6 3.7290644387e+05
R_Dense_2_105_6 L1_N105 L2_N6 1.1433833030e+05
R_Dense_2_106_6 L1_N106 L2_N6 1.0301263573e+05
R_Dense_2_107_6 L1_N107 L2_N6 1.2335032698e+05
R_Dense_2_108_6 L1_N108 L2_N6 2.7193708223e+05
R_Dense_2_109_6 L1_N109 L2_N6 1.9562372296e+05
R_Dense_2_110_6 L1_N110 L2_N6 2.3283194003e+05
R_Dense_2_111_6 L1_N111 L2_N6 1.2316299294e+05
R_Dense_2_112_6 L1_N112 L2_N6 2.2606889709e+05
R_Dense_2_113_6 L1_N113 L2_N6 2.0107495614e+05
R_Dense_2_114_6 L1_N114 L2_N6 2.7200891996e+05
R_Dense_2_115_6 L1_N115 L2_N6 1.6801847634e+05
R_Dense_2_116_6 L1_N116 L2_N6 1.1946614863e+05
R_Dense_2_117_6 L1_N117 L2_N6 1.7978159035e+05
R_Dense_2_118_6 L1_N118 L2_N6 1.2145358343e+05
R_Dense_2_119_6 L1_N119 L2_N6 1.0823340303e+05
R_Dense_2_120_6 L1_N120 L2_N6 3.6666649787e+05
R_Dense_2_121_6 L1_N121 L2_N6 2.7224690786e+06
R_Dense_2_122_6 L1_N122 L2_N6 2.2840803727e+05
R_Dense_2_123_6 L1_N123 L2_N6 6.0436473028e+05
R_Dense_2_124_6 L1_N124 L2_N6 3.4644775271e+05
R_Dense_2_125_6 L1_N125 L2_N6 2.0941564982e+05
R_Dense_2_126_6 L1_N126 L2_N6 8.0538377856e+05
R_Dense_2_127_6 L1_N127 L2_N6 1.7920510960e+05
R_Dense_2_128_6 L1_N128 L2_N6 1.5631533331e+05
R_Dense_2_129_6 L1_N129 L2_N6 1.0599457553e+05
R_Dense_2_130_6 L1_N130 L2_N6 2.2045887429e+05
R_Dense_2_131_6 L1_N131 L2_N6 1.0857781617e+05
R_Dense_2_132_6 L1_N132 L2_N6 2.8619306190e+05
R_Dense_2_133_6 L1_N133 L2_N6 7.3924272525e+05
R_Dense_2_134_6 L1_N134 L2_N6 1.7176146231e+05
R_Dense_2_135_6 L1_N135 L2_N6 1.5105342313e+06
R_Dense_2_136_6 L1_N136 L2_N6 1.7221109798e+05
R_Dense_2_137_6 L1_N137 L2_N6 1.8146406398e+05
R_Dense_2_138_6 L1_N138 L2_N6 1.4990163898e+05
R_Dense_2_139_6 L1_N139 L2_N6 1.2262353788e+05
R_Dense_2_140_6 L1_N140 L2_N6 2.2292293003e+05
R_Dense_2_141_6 L1_N141 L2_N6 3.1082465925e+05
R_Dense_2_142_6 L1_N142 L2_N6 1.4305115514e+05
R_Dense_2_143_6 L1_N143 L2_N6 1.0103720458e+05
R_Dense_2_144_6 L1_N144 L2_N6 1.0092291488e+05
R_Dense_2_145_6 L1_N145 L2_N6 1.6752046599e+05
R_Dense_2_146_6 L1_N146 L2_N6 3.7383530130e+06
R_Dense_2_147_6 L1_N147 L2_N6 1.8008336923e+05
R_Dense_2_148_6 L1_N148 L2_N6 1.0819138980e+05
R_Dense_2_149_6 L1_N149 L2_N6 1.3571972200e+06
R_Dense_2_150_6 L1_N150 L2_N6 1.1352019342e+05
R_Dense_2_151_6 L1_N151 L2_N6 1.0376840797e+05
R_Dense_2_152_6 L1_N152 L2_N6 1.6260401490e+05
R_Dense_2_153_6 L1_N153 L2_N6 7.0951248843e+05
R_Dense_2_154_6 L1_N154 L2_N6 1.0185520545e+05
R_Dense_2_155_6 L1_N155 L2_N6 1.1837521020e+05
R_Dense_2_156_6 L1_N156 L2_N6 2.8242390706e+05
R_Dense_2_157_6 L1_N157 L2_N6 1.6245972261e+06
R_Dense_2_158_6 L1_N158 L2_N6 1.7876003628e+05
R_Dense_2_159_6 L1_N159 L2_N6 1.4880823924e+05
R_Dense_2_160_6 L1_N160 L2_N6 3.2796477062e+05
R_Dense_2_161_6 L1_N161 L2_N6 1.0777457545e+06
R_Dense_2_162_6 L1_N162 L2_N6 3.7012564513e+05
R_Dense_2_163_6 L1_N163 L2_N6 2.2788369393e+05
R_Dense_2_164_6 L1_N164 L2_N6 2.4169257518e+05
R_Dense_2_165_6 L1_N165 L2_N6 1.1622423487e+05
R_Dense_2_166_6 L1_N166 L2_N6 5.9924174377e+05
R_Dense_2_167_6 L1_N167 L2_N6 2.9584641847e+05
R_Dense_2_168_6 L1_N168 L2_N6 1.5445640664e+06
R_Dense_2_169_6 L1_N169 L2_N6 2.8085758254e+05
R_Dense_2_170_6 L1_N170 L2_N6 2.3317319317e+05
R_Dense_2_171_6 L1_N171 L2_N6 7.2225514866e+05
R_Dense_2_172_6 L1_N172 L2_N6 1.9571583493e+05
R_Dense_2_173_6 L1_N173 L2_N6 1.2263700397e+05
R_Dense_2_174_6 L1_N174 L2_N6 1.3478605868e+05
R_Dense_2_175_6 L1_N175 L2_N6 2.1142438640e+05
R_Dense_2_176_6 L1_N176 L2_N6 2.5327363535e+05
R_Dense_2_177_6 L1_N177 L2_N6 1.2491778288e+05
R_Dense_2_178_6 L1_N178 L2_N6 6.4490970914e+05
R_Dense_2_179_6 L1_N179 L2_N6 1.8423863292e+05
R_Dense_2_180_6 L1_N180 L2_N6 1.6340992815e+05
R_Dense_2_181_6 L1_N181 L2_N6 1.3364583374e+05
R_Dense_2_182_6 L1_N182 L2_N6 1.0564684838e+05
R_Dense_2_183_6 L1_N183 L2_N6 3.0069339165e+05
R_Dense_2_184_6 L1_N184 L2_N6 1.0809125135e+05
R_Dense_2_185_6 L1_N185 L2_N6 1.1417392343e+05
R_Dense_2_186_6 L1_N186 L2_N6 4.6025040763e+06
R_Dense_2_187_6 L1_N187 L2_N6 1.0977630018e+05
R_Dense_2_188_6 L1_N188 L2_N6 1.0093279435e+05
R_Dense_2_189_6 L1_N189 L2_N6 6.8122927085e+05
R_Dense_2_190_6 L1_N190 L2_N6 3.0307983462e+05
R_Dense_2_191_6 L1_N191 L2_N6 1.2266720658e+05
R_Dense_2_192_6 L1_N192 L2_N6 2.2481324047e+05
R_Dense_2_193_6 L1_N193 L2_N6 1.9137131687e+05
R_Dense_2_194_6 L1_N194 L2_N6 1.2580342783e+05
R_Dense_2_195_6 L1_N195 L2_N6 2.5006769967e+05
R_Dense_2_196_6 L1_N196 L2_N6 2.6219513680e+05
R_Dense_2_197_6 L1_N197 L2_N6 4.8180609471e+05
R_Dense_2_198_6 L1_N198 L2_N6 3.9828137074e+05
R_Dense_2_199_6 L1_N199 L2_N6 4.9149710764e+05
R_Dense_2_200_6 L1_N200 L2_N6 7.8483405483e+06
R_Dense_2_201_6 L1_N201 L2_N6 1.3569457613e+05
R_Dense_2_202_6 L1_N202 L2_N6 1.5146899627e+05
R_Dense_2_203_6 L1_N203 L2_N6 1.4004484602e+06
R_Dense_2_204_6 L1_N204 L2_N6 5.1236866619e+05
R_Dense_2_205_6 L1_N205 L2_N6 1.0410949432e+05
R_Dense_2_206_6 L1_N206 L2_N6 1.3079871133e+05
R_Dense_2_207_6 L1_N207 L2_N6 3.0542034199e+05
R_Dense_2_208_6 L1_N208 L2_N6 1.0315181206e+05
R_Dense_2_209_6 L1_N209 L2_N6 1.3026133407e+05
R_Dense_2_210_6 L1_N210 L2_N6 1.3523571404e+05
R_Dense_2_211_6 L1_N211 L2_N6 1.0430867087e+05
R_Dense_2_212_6 L1_N212 L2_N6 1.6971532535e+05
R_Dense_2_213_6 L1_N213 L2_N6 1.0496391381e+05
R_Dense_2_214_6 L1_N214 L2_N6 1.2255587537e+05
R_Dense_2_215_6 L1_N215 L2_N6 1.2803529040e+05
R_Dense_2_216_6 L1_N216 L2_N6 2.7447353534e+05
R_Dense_2_217_6 L1_N217 L2_N6 1.5083569892e+06
R_Dense_2_218_6 L1_N218 L2_N6 1.4243449547e+05
R_Dense_2_219_6 L1_N219 L2_N6 2.7494932762e+06
R_Dense_2_220_6 L1_N220 L2_N6 1.3784024189e+05
R_Dense_2_221_6 L1_N221 L2_N6 1.2783718126e+05
R_Dense_2_222_6 L1_N222 L2_N6 3.0628364222e+05
R_Dense_2_223_6 L1_N223 L2_N6 9.2900272674e+05
R_Dense_2_224_6 L1_N224 L2_N6 2.2447666447e+05
R_Dense_2_225_6 L1_N225 L2_N6 2.3227188203e+05
R_Dense_2_226_6 L1_N226 L2_N6 8.7894544861e+05
R_Dense_2_227_6 L1_N227 L2_N6 1.0457316983e+05
R_Dense_2_228_6 L1_N228 L2_N6 1.2896170075e+05
R_Dense_2_229_6 L1_N229 L2_N6 3.3802886826e+05
R_Dense_2_230_6 L1_N230 L2_N6 1.4974837901e+05
R_Dense_2_231_6 L1_N231 L2_N6 1.0308269101e+05
R_Dense_2_232_6 L1_N232 L2_N6 1.8240611983e+06
R_Dense_2_233_6 L1_N233 L2_N6 1.5877639446e+05
R_Dense_2_234_6 L1_N234 L2_N6 1.3129468873e+05
R_Dense_2_235_6 L1_N235 L2_N6 2.5297658178e+05
R_Dense_2_236_6 L1_N236 L2_N6 6.8337687741e+05
R_Dense_2_237_6 L1_N237 L2_N6 1.4436886158e+05
R_Dense_2_238_6 L1_N238 L2_N6 1.3702364014e+05
R_Dense_2_239_6 L1_N239 L2_N6 1.1414449929e+05
R_Dense_2_240_6 L1_N240 L2_N6 1.1301786802e+05
R_Dense_2_241_6 L1_N241 L2_N6 1.1713276479e+05
R_Dense_2_242_6 L1_N242 L2_N6 1.7115102258e+05
R_Dense_2_243_6 L1_N243 L2_N6 3.1027777983e+05
R_Dense_2_244_6 L1_N244 L2_N6 1.0019174258e+05
R_Dense_2_245_6 L1_N245 L2_N6 2.5434148098e+05
R_Dense_2_246_6 L1_N246 L2_N6 1.2652976934e+05
R_Dense_2_247_6 L1_N247 L2_N6 1.1672200055e+05
R_Dense_2_248_6 L1_N248 L2_N6 6.1911285863e+05
R_Dense_2_249_6 L1_N249 L2_N6 2.0862331602e+05
R_Dense_2_250_6 L1_N250 L2_N6 1.2188557873e+06
R_Dense_2_251_6 L1_N251 L2_N6 6.9103824495e+05
R_Dense_2_252_6 L1_N252 L2_N6 3.1958779668e+05
R_Dense_2_253_6 L1_N253 L2_N6 4.2443411995e+05
R_Dense_2_254_6 L1_N254 L2_N6 1.0970743632e+05
R_Dense_2_255_6 L1_N255 L2_N6 5.0672939191e+05
R_Dense_2_256_6 L1_N256 L2_N6 3.0222610518e+06
R_Dense_2_257_6 L1_N257 L2_N6 1.4393046522e+05
R_Dense_2_258_6 L1_N258 L2_N6 4.3336843948e+05
R_Dense_2_259_6 L1_N259 L2_N6 1.2566892650e+05
R_Dense_2_260_6 L1_N260 L2_N6 1.1739677374e+05
R_Dense_2_261_6 L1_N261 L2_N6 2.1276499965e+05
R_Dense_2_262_6 L1_N262 L2_N6 1.7896390569e+05
R_Dense_2_263_6 L1_N263 L2_N6 1.0554533534e+05
R_Dense_2_264_6 L1_N264 L2_N6 1.1503421349e+05
R_Dense_2_265_6 L1_N265 L2_N6 5.8345749308e+05
R_Dense_2_266_6 L1_N266 L2_N6 1.6536430682e+05
R_Dense_2_267_6 L1_N267 L2_N6 1.4624711932e+05
R_Dense_2_268_6 L1_N268 L2_N6 1.2394556918e+05
R_Dense_2_269_6 L1_N269 L2_N6 5.5216923752e+05
R_Dense_2_270_6 L1_N270 L2_N6 9.4764654265e+05
R_Dense_2_271_6 L1_N271 L2_N6 3.2320411135e+05
R_Dense_2_272_6 L1_N272 L2_N6 1.8317556896e+05
R_Dense_2_273_6 L1_N273 L2_N6 2.5848098604e+05
R_Dense_2_274_6 L1_N274 L2_N6 3.0992451197e+05
R_Dense_2_275_6 L1_N275 L2_N6 1.0625717227e+05
R_Dense_2_276_6 L1_N276 L2_N6 1.1131140848e+06
R_Dense_2_277_6 L1_N277 L2_N6 2.4671663899e+05
R_Dense_2_278_6 L1_N278 L2_N6 3.2566364738e+05
R_Dense_2_279_6 L1_N279 L2_N6 7.1850036104e+05
R_Dense_2_280_6 L1_N280 L2_N6 8.3228413192e+05
R_Dense_2_281_6 L1_N281 L2_N6 3.0882890037e+05
R_Dense_2_282_6 L1_N282 L2_N6 2.7346068677e+05
R_Dense_2_283_6 L1_N283 L2_N6 1.3314493779e+05
R_Dense_2_284_6 L1_N284 L2_N6 1.0478106914e+05
R_Dense_2_285_6 L1_N285 L2_N6 6.7252018932e+05
R_Dense_2_286_6 L1_N286 L2_N6 1.3525178406e+05
R_Dense_2_287_6 L1_N287 L2_N6 1.1373134948e+05
R_Dense_2_288_6 L1_N288 L2_N6 4.7535798878e+05
R_Dense_2_289_6 L1_N289 L2_N6 1.7635040195e+05
R_Dense_2_290_6 L1_N290 L2_N6 1.3885236397e+05
R_Dense_2_291_6 L1_N291 L2_N6 4.7811947004e+06
R_Dense_2_292_6 L1_N292 L2_N6 1.1357285202e+05
R_Dense_2_293_6 L1_N293 L2_N6 1.3834850541e+05
R_Dense_2_294_6 L1_N294 L2_N6 1.5815625498e+06
R_Dense_2_295_6 L1_N295 L2_N6 6.7074371774e+06
R_Dense_2_296_6 L1_N296 L2_N6 1.1107920484e+05
R_Dense_2_297_6 L1_N297 L2_N6 1.2790179669e+05
R_Dense_2_298_6 L1_N298 L2_N6 5.1724215596e+05
R_Dense_2_299_6 L1_N299 L2_N6 6.8807087877e+05
R_Dense_2_300_6 L1_N300 L2_N6 6.6304367148e+05
R_Dense_2_301_6 L1_N301 L2_N6 3.2113350831e+05
R_Dense_2_302_6 L1_N302 L2_N6 4.1724254908e+05
R_Dense_2_303_6 L1_N303 L2_N6 2.4806386882e+05
R_Dense_2_304_6 L1_N304 L2_N6 1.3225136254e+05
R_Dense_2_305_6 L1_N305 L2_N6 2.4229050607e+05
R_Dense_2_306_6 L1_N306 L2_N6 2.1916123865e+05
R_Dense_2_307_6 L1_N307 L2_N6 2.0885175272e+05
R_Dense_2_308_6 L1_N308 L2_N6 4.4907842673e+05
R_Dense_2_309_6 L1_N309 L2_N6 2.7046363957e+05
R_Dense_2_310_6 L1_N310 L2_N6 7.2465418908e+05
R_Dense_2_311_6 L1_N311 L2_N6 1.8107882193e+05
R_Dense_2_312_6 L1_N312 L2_N6 1.8914016842e+05
R_Dense_2_313_6 L1_N313 L2_N6 2.4980268063e+05
R_Dense_2_314_6 L1_N314 L2_N6 1.0885160317e+06
R_Dense_2_315_6 L1_N315 L2_N6 1.0149903984e+05
R_Dense_2_316_6 L1_N316 L2_N6 3.8419357148e+05
R_Dense_2_317_6 L1_N317 L2_N6 3.4961900819e+05
R_Dense_2_318_6 L1_N318 L2_N6 1.4793669343e+05
R_Dense_2_319_6 L1_N319 L2_N6 5.0675196566e+05
R_Dense_2_320_6 L1_N320 L2_N6 2.5089867573e+05
R_Dense_2_321_6 L1_N321 L2_N6 1.2713363777e+05
R_Dense_2_322_6 L1_N322 L2_N6 4.0595449844e+05
R_Dense_2_323_6 L1_N323 L2_N6 1.4054657099e+05
R_Dense_2_324_6 L1_N324 L2_N6 7.3511149532e+05
R_Dense_2_325_6 L1_N325 L2_N6 1.6859278747e+05
R_Dense_2_326_6 L1_N326 L2_N6 2.5497428974e+05
R_Dense_2_327_6 L1_N327 L2_N6 4.5002364963e+05
R_Dense_2_328_6 L1_N328 L2_N6 1.8345433550e+05
R_Dense_2_329_6 L1_N329 L2_N6 1.3502195443e+05
R_Dense_2_330_6 L1_N330 L2_N6 1.1655876359e+05
R_Dense_2_331_6 L1_N331 L2_N6 1.5625210193e+06
R_Dense_2_332_6 L1_N332 L2_N6 1.1588943521e+05
R_Dense_2_333_6 L1_N333 L2_N6 3.5429809590e+05
R_Dense_2_334_6 L1_N334 L2_N6 1.4632205388e+06
R_Dense_2_335_6 L1_N335 L2_N6 2.9516138865e+05
R_Dense_2_336_6 L1_N336 L2_N6 1.3168232460e+05
R_Dense_2_337_6 L1_N337 L2_N6 1.0590985059e+05
*
R_Dense_2_0_7 L1_N0 L2_N7 1.3850733950e+05
R_Dense_2_1_7 L1_N1 L2_N7 2.2015609061e+05
R_Dense_2_2_7 L1_N2 L2_N7 7.6572963872e+05
R_Dense_2_3_7 L1_N3 L2_N7 1.3469766110e+05
R_Dense_2_4_7 L1_N4 L2_N7 1.4597288448e+05
R_Dense_2_5_7 L1_N5 L2_N7 2.7800095255e+05
R_Dense_2_6_7 L1_N6 L2_N7 2.9172723013e+05
R_Dense_2_7_7 L1_N7 L2_N7 1.0534938743e+05
R_Dense_2_8_7 L1_N8 L2_N7 4.9861732238e+05
R_Dense_2_9_7 L1_N9 L2_N7 1.8424779665e+05
R_Dense_2_10_7 L1_N10 L2_N7 2.0137047700e+05
R_Dense_2_11_7 L1_N11 L2_N7 1.0577291161e+05
R_Dense_2_12_7 L1_N12 L2_N7 1.0128517843e+05
R_Dense_2_13_7 L1_N13 L2_N7 2.1231922039e+05
R_Dense_2_14_7 L1_N14 L2_N7 2.4099827245e+05
R_Dense_2_15_7 L1_N15 L2_N7 1.1291460523e+05
R_Dense_2_16_7 L1_N16 L2_N7 1.7084873086e+05
R_Dense_2_17_7 L1_N17 L2_N7 3.3575668679e+05
R_Dense_2_18_7 L1_N18 L2_N7 1.1610251795e+05
R_Dense_2_19_7 L1_N19 L2_N7 5.1607837392e+05
R_Dense_2_20_7 L1_N20 L2_N7 1.1646968157e+06
R_Dense_2_21_7 L1_N21 L2_N7 6.1423540277e+05
R_Dense_2_22_7 L1_N22 L2_N7 1.4338156950e+06
R_Dense_2_23_7 L1_N23 L2_N7 1.7260602160e+05
R_Dense_2_24_7 L1_N24 L2_N7 2.1854139071e+05
R_Dense_2_25_7 L1_N25 L2_N7 1.2147256292e+05
R_Dense_2_26_7 L1_N26 L2_N7 1.6172511772e+05
R_Dense_2_27_7 L1_N27 L2_N7 1.6215151256e+05
R_Dense_2_28_7 L1_N28 L2_N7 3.9070463234e+05
R_Dense_2_29_7 L1_N29 L2_N7 1.2996710835e+05
R_Dense_2_30_7 L1_N30 L2_N7 2.3898387066e+05
R_Dense_2_31_7 L1_N31 L2_N7 6.9341613492e+05
R_Dense_2_32_7 L1_N32 L2_N7 2.0420242894e+05
R_Dense_2_33_7 L1_N33 L2_N7 2.0727746229e+05
R_Dense_2_34_7 L1_N34 L2_N7 5.9168369170e+05
R_Dense_2_35_7 L1_N35 L2_N7 1.9799366703e+05
R_Dense_2_36_7 L1_N36 L2_N7 1.0505995501e+05
R_Dense_2_37_7 L1_N37 L2_N7 1.1212582396e+05
R_Dense_2_38_7 L1_N38 L2_N7 6.4963329098e+05
R_Dense_2_39_7 L1_N39 L2_N7 1.2230881089e+05
R_Dense_2_40_7 L1_N40 L2_N7 1.0747793276e+05
R_Dense_2_41_7 L1_N41 L2_N7 2.4927178272e+05
R_Dense_2_42_7 L1_N42 L2_N7 2.5975729081e+05
R_Dense_2_43_7 L1_N43 L2_N7 1.0673240755e+05
R_Dense_2_44_7 L1_N44 L2_N7 1.1186004388e+05
R_Dense_2_45_7 L1_N45 L2_N7 2.9242085530e+05
R_Dense_2_46_7 L1_N46 L2_N7 1.3972018495e+05
R_Dense_2_47_7 L1_N47 L2_N7 1.0229712587e+05
R_Dense_2_48_7 L1_N48 L2_N7 1.0774079663e+05
R_Dense_2_49_7 L1_N49 L2_N7 1.4921207469e+05
R_Dense_2_50_7 L1_N50 L2_N7 1.4220783099e+05
R_Dense_2_51_7 L1_N51 L2_N7 3.1128799257e+05
R_Dense_2_52_7 L1_N52 L2_N7 2.0909357340e+05
R_Dense_2_53_7 L1_N53 L2_N7 1.0783477133e+05
R_Dense_2_54_7 L1_N54 L2_N7 1.4815658942e+05
R_Dense_2_55_7 L1_N55 L2_N7 1.3331993614e+05
R_Dense_2_56_7 L1_N56 L2_N7 2.0320163556e+05
R_Dense_2_57_7 L1_N57 L2_N7 1.3759385879e+05
R_Dense_2_58_7 L1_N58 L2_N7 1.5054708217e+05
R_Dense_2_59_7 L1_N59 L2_N7 1.0146442175e+05
R_Dense_2_60_7 L1_N60 L2_N7 2.0682351368e+05
R_Dense_2_61_7 L1_N61 L2_N7 3.7956643162e+05
R_Dense_2_62_7 L1_N62 L2_N7 1.5687530751e+05
R_Dense_2_63_7 L1_N63 L2_N7 9.6357206923e+05
R_Dense_2_64_7 L1_N64 L2_N7 2.0015225806e+05
R_Dense_2_65_7 L1_N65 L2_N7 1.4686058447e+05
R_Dense_2_66_7 L1_N66 L2_N7 2.2059271017e+05
R_Dense_2_67_7 L1_N67 L2_N7 4.6567444182e+05
R_Dense_2_68_7 L1_N68 L2_N7 1.9626359019e+05
R_Dense_2_69_7 L1_N69 L2_N7 3.1057787749e+05
R_Dense_2_70_7 L1_N70 L2_N7 2.2094444611e+06
R_Dense_2_71_7 L1_N71 L2_N7 1.7092994677e+05
R_Dense_2_72_7 L1_N72 L2_N7 3.7273723725e+05
R_Dense_2_73_7 L1_N73 L2_N7 3.6783867708e+05
R_Dense_2_74_7 L1_N74 L2_N7 4.3215459282e+06
R_Dense_2_75_7 L1_N75 L2_N7 2.5179328139e+05
R_Dense_2_76_7 L1_N76 L2_N7 2.1552766606e+05
R_Dense_2_77_7 L1_N77 L2_N7 1.0239983964e+05
R_Dense_2_78_7 L1_N78 L2_N7 1.0986989330e+05
R_Dense_2_79_7 L1_N79 L2_N7 1.8523942576e+05
R_Dense_2_80_7 L1_N80 L2_N7 4.4910269505e+05
R_Dense_2_81_7 L1_N81 L2_N7 1.6894830943e+05
R_Dense_2_82_7 L1_N82 L2_N7 4.5634611046e+05
R_Dense_2_83_7 L1_N83 L2_N7 1.1855151100e+05
R_Dense_2_84_7 L1_N84 L2_N7 1.4223691019e+05
R_Dense_2_85_7 L1_N85 L2_N7 1.0457871588e+05
R_Dense_2_86_7 L1_N86 L2_N7 1.4108332001e+05
R_Dense_2_87_7 L1_N87 L2_N7 2.8244985359e+05
R_Dense_2_88_7 L1_N88 L2_N7 3.3986900833e+05
R_Dense_2_89_7 L1_N89 L2_N7 3.0579882554e+05
R_Dense_2_90_7 L1_N90 L2_N7 4.1660444907e+05
R_Dense_2_91_7 L1_N91 L2_N7 3.0362203006e+05
R_Dense_2_92_7 L1_N92 L2_N7 1.5603324818e+05
R_Dense_2_93_7 L1_N93 L2_N7 2.0283737471e+06
R_Dense_2_94_7 L1_N94 L2_N7 1.6540561923e+05
R_Dense_2_95_7 L1_N95 L2_N7 1.2655640499e+06
R_Dense_2_96_7 L1_N96 L2_N7 1.2916438083e+05
R_Dense_2_97_7 L1_N97 L2_N7 1.4904595473e+05
R_Dense_2_98_7 L1_N98 L2_N7 6.3457751058e+05
R_Dense_2_99_7 L1_N99 L2_N7 1.9899872140e+05
R_Dense_2_100_7 L1_N100 L2_N7 1.6535524176e+05
R_Dense_2_101_7 L1_N101 L2_N7 7.6186747946e+05
R_Dense_2_102_7 L1_N102 L2_N7 1.7760487131e+05
R_Dense_2_103_7 L1_N103 L2_N7 3.6128492005e+05
R_Dense_2_104_7 L1_N104 L2_N7 1.7226314155e+05
R_Dense_2_105_7 L1_N105 L2_N7 4.4199038634e+05
R_Dense_2_106_7 L1_N106 L2_N7 1.1241437723e+05
R_Dense_2_107_7 L1_N107 L2_N7 8.4120458030e+05
R_Dense_2_108_7 L1_N108 L2_N7 1.1322624574e+05
R_Dense_2_109_7 L1_N109 L2_N7 2.3585632307e+05
R_Dense_2_110_7 L1_N110 L2_N7 2.8075212700e+05
R_Dense_2_111_7 L1_N111 L2_N7 1.3219499305e+05
R_Dense_2_112_7 L1_N112 L2_N7 1.7104673389e+05
R_Dense_2_113_7 L1_N113 L2_N7 3.6296539711e+05
R_Dense_2_114_7 L1_N114 L2_N7 3.8304284838e+05
R_Dense_2_115_7 L1_N115 L2_N7 1.5738982083e+06
R_Dense_2_116_7 L1_N116 L2_N7 1.0740495652e+05
R_Dense_2_117_7 L1_N117 L2_N7 1.0410873230e+05
R_Dense_2_118_7 L1_N118 L2_N7 6.0971780492e+05
R_Dense_2_119_7 L1_N119 L2_N7 6.2060361330e+05
R_Dense_2_120_7 L1_N120 L2_N7 1.0926599359e+05
R_Dense_2_121_7 L1_N121 L2_N7 2.0559426864e+05
R_Dense_2_122_7 L1_N122 L2_N7 1.7202356495e+05
R_Dense_2_123_7 L1_N123 L2_N7 1.3259418917e+05
R_Dense_2_124_7 L1_N124 L2_N7 5.6302154158e+05
R_Dense_2_125_7 L1_N125 L2_N7 3.7288403101e+05
R_Dense_2_126_7 L1_N126 L2_N7 1.1903142974e+05
R_Dense_2_127_7 L1_N127 L2_N7 8.2340088510e+05
R_Dense_2_128_7 L1_N128 L2_N7 1.5347690708e+05
R_Dense_2_129_7 L1_N129 L2_N7 3.9526591629e+05
R_Dense_2_130_7 L1_N130 L2_N7 1.3788149234e+05
R_Dense_2_131_7 L1_N131 L2_N7 1.5481788530e+05
R_Dense_2_132_7 L1_N132 L2_N7 2.1370528083e+05
R_Dense_2_133_7 L1_N133 L2_N7 1.1681023832e+05
R_Dense_2_134_7 L1_N134 L2_N7 3.1330683492e+05
R_Dense_2_135_7 L1_N135 L2_N7 2.1703603067e+05
R_Dense_2_136_7 L1_N136 L2_N7 2.0528650801e+05
R_Dense_2_137_7 L1_N137 L2_N7 1.3031220289e+05
R_Dense_2_138_7 L1_N138 L2_N7 1.2715073049e+05
R_Dense_2_139_7 L1_N139 L2_N7 8.7847222082e+05
R_Dense_2_140_7 L1_N140 L2_N7 1.9796271279e+05
R_Dense_2_141_7 L1_N141 L2_N7 1.3933231845e+05
R_Dense_2_142_7 L1_N142 L2_N7 3.6511205486e+05
R_Dense_2_143_7 L1_N143 L2_N7 1.2285462055e+05
R_Dense_2_144_7 L1_N144 L2_N7 5.3570786335e+05
R_Dense_2_145_7 L1_N145 L2_N7 1.5318751187e+06
R_Dense_2_146_7 L1_N146 L2_N7 2.0896694041e+05
R_Dense_2_147_7 L1_N147 L2_N7 1.0625110829e+05
R_Dense_2_148_7 L1_N148 L2_N7 1.8745655368e+05
R_Dense_2_149_7 L1_N149 L2_N7 1.0143246270e+05
R_Dense_2_150_7 L1_N150 L2_N7 2.8724949440e+06
R_Dense_2_151_7 L1_N151 L2_N7 1.7878858962e+05
R_Dense_2_152_7 L1_N152 L2_N7 2.1989822215e+05
R_Dense_2_153_7 L1_N153 L2_N7 1.0005787116e+05
R_Dense_2_154_7 L1_N154 L2_N7 1.3468950127e+05
R_Dense_2_155_7 L1_N155 L2_N7 8.0696913847e+05
R_Dense_2_156_7 L1_N156 L2_N7 1.7376681541e+06
R_Dense_2_157_7 L1_N157 L2_N7 1.0313873995e+05
R_Dense_2_158_7 L1_N158 L2_N7 7.1091134795e+05
R_Dense_2_159_7 L1_N159 L2_N7 5.9905493447e+05
R_Dense_2_160_7 L1_N160 L2_N7 2.6232210595e+05
R_Dense_2_161_7 L1_N161 L2_N7 1.4039255981e+05
R_Dense_2_162_7 L1_N162 L2_N7 2.6122748474e+05
R_Dense_2_163_7 L1_N163 L2_N7 1.5170460047e+05
R_Dense_2_164_7 L1_N164 L2_N7 7.4281195587e+05
R_Dense_2_165_7 L1_N165 L2_N7 1.4877323463e+05
R_Dense_2_166_7 L1_N166 L2_N7 1.2748520187e+05
R_Dense_2_167_7 L1_N167 L2_N7 1.0444429106e+05
R_Dense_2_168_7 L1_N168 L2_N7 2.5588218792e+05
R_Dense_2_169_7 L1_N169 L2_N7 1.4344554288e+05
R_Dense_2_170_7 L1_N170 L2_N7 1.8155247071e+05
R_Dense_2_171_7 L1_N171 L2_N7 1.1513193331e+05
R_Dense_2_172_7 L1_N172 L2_N7 3.5874473435e+05
R_Dense_2_173_7 L1_N173 L2_N7 8.2755924914e+05
R_Dense_2_174_7 L1_N174 L2_N7 1.2444588122e+05
R_Dense_2_175_7 L1_N175 L2_N7 2.2448811065e+06
R_Dense_2_176_7 L1_N176 L2_N7 5.8629482853e+05
R_Dense_2_177_7 L1_N177 L2_N7 5.1315494056e+05
R_Dense_2_178_7 L1_N178 L2_N7 8.6990012418e+05
R_Dense_2_179_7 L1_N179 L2_N7 1.0177946520e+05
R_Dense_2_180_7 L1_N180 L2_N7 1.0993320084e+06
R_Dense_2_181_7 L1_N181 L2_N7 1.8185417438e+05
R_Dense_2_182_7 L1_N182 L2_N7 1.2921097104e+05
R_Dense_2_183_7 L1_N183 L2_N7 1.0390081283e+05
R_Dense_2_184_7 L1_N184 L2_N7 3.7554260715e+05
R_Dense_2_185_7 L1_N185 L2_N7 1.7427720108e+05
R_Dense_2_186_7 L1_N186 L2_N7 1.1069947364e+05
R_Dense_2_187_7 L1_N187 L2_N7 1.4571641896e+06
R_Dense_2_188_7 L1_N188 L2_N7 1.4024923916e+05
R_Dense_2_189_7 L1_N189 L2_N7 5.6095660907e+05
R_Dense_2_190_7 L1_N190 L2_N7 2.0583754984e+05
R_Dense_2_191_7 L1_N191 L2_N7 2.6815678332e+05
R_Dense_2_192_7 L1_N192 L2_N7 1.7760143623e+05
R_Dense_2_193_7 L1_N193 L2_N7 1.3279416390e+05
R_Dense_2_194_7 L1_N194 L2_N7 1.2270315330e+05
R_Dense_2_195_7 L1_N195 L2_N7 1.0563918744e+05
R_Dense_2_196_7 L1_N196 L2_N7 1.6563318771e+05
R_Dense_2_197_7 L1_N197 L2_N7 1.3003939964e+05
R_Dense_2_198_7 L1_N198 L2_N7 2.1472401318e+05
R_Dense_2_199_7 L1_N199 L2_N7 1.3014578199e+05
R_Dense_2_200_7 L1_N200 L2_N7 1.1335199910e+05
R_Dense_2_201_7 L1_N201 L2_N7 8.6202709867e+05
R_Dense_2_202_7 L1_N202 L2_N7 1.3764366955e+05
R_Dense_2_203_7 L1_N203 L2_N7 1.2065130699e+05
R_Dense_2_204_7 L1_N204 L2_N7 1.6620303072e+05
R_Dense_2_205_7 L1_N205 L2_N7 1.0651398848e+05
R_Dense_2_206_7 L1_N206 L2_N7 2.2022055164e+05
R_Dense_2_207_7 L1_N207 L2_N7 7.0414247586e+05
R_Dense_2_208_7 L1_N208 L2_N7 2.0379599305e+05
R_Dense_2_209_7 L1_N209 L2_N7 1.0746935737e+05
R_Dense_2_210_7 L1_N210 L2_N7 1.4432084018e+05
R_Dense_2_211_7 L1_N211 L2_N7 2.4495950099e+05
R_Dense_2_212_7 L1_N212 L2_N7 1.2105855293e+05
R_Dense_2_213_7 L1_N213 L2_N7 1.9190827522e+05
R_Dense_2_214_7 L1_N214 L2_N7 2.0957839263e+05
R_Dense_2_215_7 L1_N215 L2_N7 1.2621519222e+05
R_Dense_2_216_7 L1_N216 L2_N7 1.4397261949e+06
R_Dense_2_217_7 L1_N217 L2_N7 4.6385070384e+05
R_Dense_2_218_7 L1_N218 L2_N7 2.4552520686e+05
R_Dense_2_219_7 L1_N219 L2_N7 1.5878469179e+05
R_Dense_2_220_7 L1_N220 L2_N7 5.0449394351e+05
R_Dense_2_221_7 L1_N221 L2_N7 1.7802259233e+05
R_Dense_2_222_7 L1_N222 L2_N7 1.4013248400e+05
R_Dense_2_223_7 L1_N223 L2_N7 1.5625601157e+05
R_Dense_2_224_7 L1_N224 L2_N7 1.0687925352e+05
R_Dense_2_225_7 L1_N225 L2_N7 1.9635462944e+05
R_Dense_2_226_7 L1_N226 L2_N7 1.2772593130e+05
R_Dense_2_227_7 L1_N227 L2_N7 1.2902030702e+05
R_Dense_2_228_7 L1_N228 L2_N7 2.2437724600e+05
R_Dense_2_229_7 L1_N229 L2_N7 1.7981951881e+05
R_Dense_2_230_7 L1_N230 L2_N7 1.9177305549e+05
R_Dense_2_231_7 L1_N231 L2_N7 3.3587997683e+05
R_Dense_2_232_7 L1_N232 L2_N7 1.5365260397e+05
R_Dense_2_233_7 L1_N233 L2_N7 4.2353021387e+05
R_Dense_2_234_7 L1_N234 L2_N7 1.2560048959e+05
R_Dense_2_235_7 L1_N235 L2_N7 2.5668026280e+05
R_Dense_2_236_7 L1_N236 L2_N7 1.9199808312e+05
R_Dense_2_237_7 L1_N237 L2_N7 2.2589336908e+05
R_Dense_2_238_7 L1_N238 L2_N7 1.2816297623e+05
R_Dense_2_239_7 L1_N239 L2_N7 1.7616777296e+05
R_Dense_2_240_7 L1_N240 L2_N7 9.2991960698e+05
R_Dense_2_241_7 L1_N241 L2_N7 5.5742835841e+05
R_Dense_2_242_7 L1_N242 L2_N7 1.0893971774e+05
R_Dense_2_243_7 L1_N243 L2_N7 1.0939858694e+05
R_Dense_2_244_7 L1_N244 L2_N7 3.1318906784e+06
R_Dense_2_245_7 L1_N245 L2_N7 1.9242197601e+05
R_Dense_2_246_7 L1_N246 L2_N7 4.8350827107e+05
R_Dense_2_247_7 L1_N247 L2_N7 4.0865690174e+05
R_Dense_2_248_7 L1_N248 L2_N7 1.3664846314e+05
R_Dense_2_249_7 L1_N249 L2_N7 1.0780109472e+05
R_Dense_2_250_7 L1_N250 L2_N7 1.3465252316e+05
R_Dense_2_251_7 L1_N251 L2_N7 1.0972097316e+05
R_Dense_2_252_7 L1_N252 L2_N7 3.4418829539e+05
R_Dense_2_253_7 L1_N253 L2_N7 1.0841576154e+06
R_Dense_2_254_7 L1_N254 L2_N7 1.9342294559e+05
R_Dense_2_255_7 L1_N255 L2_N7 2.7216582729e+05
R_Dense_2_256_7 L1_N256 L2_N7 1.0252386734e+05
R_Dense_2_257_7 L1_N257 L2_N7 3.4240932734e+05
R_Dense_2_258_7 L1_N258 L2_N7 1.0813289203e+05
R_Dense_2_259_7 L1_N259 L2_N7 4.6836152138e+05
R_Dense_2_260_7 L1_N260 L2_N7 1.0092654145e+05
R_Dense_2_261_7 L1_N261 L2_N7 2.4589440503e+05
R_Dense_2_262_7 L1_N262 L2_N7 1.4785190104e+05
R_Dense_2_263_7 L1_N263 L2_N7 1.1386193509e+05
R_Dense_2_264_7 L1_N264 L2_N7 1.0823081545e+05
R_Dense_2_265_7 L1_N265 L2_N7 1.9026060442e+05
R_Dense_2_266_7 L1_N266 L2_N7 2.1661930649e+05
R_Dense_2_267_7 L1_N267 L2_N7 1.2125074277e+05
R_Dense_2_268_7 L1_N268 L2_N7 7.6317334948e+05
R_Dense_2_269_7 L1_N269 L2_N7 2.1764233541e+05
R_Dense_2_270_7 L1_N270 L2_N7 2.4956055323e+05
R_Dense_2_271_7 L1_N271 L2_N7 1.3410056935e+06
R_Dense_2_272_7 L1_N272 L2_N7 1.4649426993e+05
R_Dense_2_273_7 L1_N273 L2_N7 2.7590139039e+05
R_Dense_2_274_7 L1_N274 L2_N7 5.1827166595e+05
R_Dense_2_275_7 L1_N275 L2_N7 1.7486098033e+06
R_Dense_2_276_7 L1_N276 L2_N7 2.2285599227e+05
R_Dense_2_277_7 L1_N277 L2_N7 1.7847753345e+05
R_Dense_2_278_7 L1_N278 L2_N7 1.2833770736e+05
R_Dense_2_279_7 L1_N279 L2_N7 9.1903902966e+05
R_Dense_2_280_7 L1_N280 L2_N7 1.7262586854e+05
R_Dense_2_281_7 L1_N281 L2_N7 1.9495959736e+05
R_Dense_2_282_7 L1_N282 L2_N7 2.3194553170e+05
R_Dense_2_283_7 L1_N283 L2_N7 1.0758831722e+05
R_Dense_2_284_7 L1_N284 L2_N7 5.5494084733e+05
R_Dense_2_285_7 L1_N285 L2_N7 1.2528507987e+05
R_Dense_2_286_7 L1_N286 L2_N7 1.5204037607e+05
R_Dense_2_287_7 L1_N287 L2_N7 1.5080305549e+05
R_Dense_2_288_7 L1_N288 L2_N7 6.4772990985e+05
R_Dense_2_289_7 L1_N289 L2_N7 1.7104815815e+05
R_Dense_2_290_7 L1_N290 L2_N7 1.7283814275e+05
R_Dense_2_291_7 L1_N291 L2_N7 1.5512309169e+05
R_Dense_2_292_7 L1_N292 L2_N7 4.0057815426e+06
R_Dense_2_293_7 L1_N293 L2_N7 1.1200201340e+05
R_Dense_2_294_7 L1_N294 L2_N7 1.5926782505e+05
R_Dense_2_295_7 L1_N295 L2_N7 1.5904118574e+05
R_Dense_2_296_7 L1_N296 L2_N7 3.6906149129e+05
R_Dense_2_297_7 L1_N297 L2_N7 2.4596624494e+05
R_Dense_2_298_7 L1_N298 L2_N7 1.0094180422e+05
R_Dense_2_299_7 L1_N299 L2_N7 1.3145008617e+05
R_Dense_2_300_7 L1_N300 L2_N7 7.2453405680e+05
R_Dense_2_301_7 L1_N301 L2_N7 4.0789175148e+05
R_Dense_2_302_7 L1_N302 L2_N7 1.1366254000e+05
R_Dense_2_303_7 L1_N303 L2_N7 4.6421586075e+05
R_Dense_2_304_7 L1_N304 L2_N7 1.8762219580e+05
R_Dense_2_305_7 L1_N305 L2_N7 4.0491153246e+05
R_Dense_2_306_7 L1_N306 L2_N7 1.5689095802e+06
R_Dense_2_307_7 L1_N307 L2_N7 1.1137860499e+05
R_Dense_2_308_7 L1_N308 L2_N7 7.0890238124e+05
R_Dense_2_309_7 L1_N309 L2_N7 4.5470272030e+05
R_Dense_2_310_7 L1_N310 L2_N7 1.1868245692e+05
R_Dense_2_311_7 L1_N311 L2_N7 2.9103283894e+05
R_Dense_2_312_7 L1_N312 L2_N7 2.7634683747e+05
R_Dense_2_313_7 L1_N313 L2_N7 2.1665673091e+05
R_Dense_2_314_7 L1_N314 L2_N7 6.9866331782e+05
R_Dense_2_315_7 L1_N315 L2_N7 4.8058458795e+05
R_Dense_2_316_7 L1_N316 L2_N7 1.3050803903e+05
R_Dense_2_317_7 L1_N317 L2_N7 1.4517293870e+05
R_Dense_2_318_7 L1_N318 L2_N7 2.1706166522e+05
R_Dense_2_319_7 L1_N319 L2_N7 2.0505937794e+05
R_Dense_2_320_7 L1_N320 L2_N7 2.4780475704e+05
R_Dense_2_321_7 L1_N321 L2_N7 3.6654441627e+06
R_Dense_2_322_7 L1_N322 L2_N7 1.7128952217e+05
R_Dense_2_323_7 L1_N323 L2_N7 4.7639909775e+05
R_Dense_2_324_7 L1_N324 L2_N7 1.8293493464e+06
R_Dense_2_325_7 L1_N325 L2_N7 3.5316022622e+05
R_Dense_2_326_7 L1_N326 L2_N7 1.1207915554e+05
R_Dense_2_327_7 L1_N327 L2_N7 6.6659067336e+05
R_Dense_2_328_7 L1_N328 L2_N7 3.5168490819e+05
R_Dense_2_329_7 L1_N329 L2_N7 1.0266783502e+05
R_Dense_2_330_7 L1_N330 L2_N7 2.1344817150e+05
R_Dense_2_331_7 L1_N331 L2_N7 2.8473482226e+05
R_Dense_2_332_7 L1_N332 L2_N7 1.1783803485e+05
R_Dense_2_333_7 L1_N333 L2_N7 5.0604714350e+06
R_Dense_2_334_7 L1_N334 L2_N7 2.2914107820e+06
R_Dense_2_335_7 L1_N335 L2_N7 1.2122285106e+05
R_Dense_2_336_7 L1_N336 L2_N7 3.2993002007e+05
R_Dense_2_337_7 L1_N337 L2_N7 1.7503518116e+05
*
R_Dense_2_0_8 L1_N0 L2_N8 1.3884531083e+05
R_Dense_2_1_8 L1_N1 L2_N8 3.8519034560e+05
R_Dense_2_2_8 L1_N2 L2_N8 2.5078884919e+06
R_Dense_2_3_8 L1_N3 L2_N8 1.0421861608e+05
R_Dense_2_4_8 L1_N4 L2_N8 2.5401052389e+05
R_Dense_2_5_8 L1_N5 L2_N8 1.2367078220e+05
R_Dense_2_6_8 L1_N6 L2_N8 1.7423405536e+05
R_Dense_2_7_8 L1_N7 L2_N8 6.9032647905e+05
R_Dense_2_8_8 L1_N8 L2_N8 1.1309114022e+05
R_Dense_2_9_8 L1_N9 L2_N8 1.1476382587e+05
R_Dense_2_10_8 L1_N10 L2_N8 3.9175267551e+05
R_Dense_2_11_8 L1_N11 L2_N8 2.2732059540e+05
R_Dense_2_12_8 L1_N12 L2_N8 1.6130487696e+05
R_Dense_2_13_8 L1_N13 L2_N8 1.9094147375e+05
R_Dense_2_14_8 L1_N14 L2_N8 5.8838272397e+05
R_Dense_2_15_8 L1_N15 L2_N8 1.5614670692e+05
R_Dense_2_16_8 L1_N16 L2_N8 1.8556750500e+05
R_Dense_2_17_8 L1_N17 L2_N8 5.3166328159e+05
R_Dense_2_18_8 L1_N18 L2_N8 1.2548429490e+06
R_Dense_2_19_8 L1_N19 L2_N8 1.2555230444e+05
R_Dense_2_20_8 L1_N20 L2_N8 2.6276419246e+05
R_Dense_2_21_8 L1_N21 L2_N8 1.8044834696e+05
R_Dense_2_22_8 L1_N22 L2_N8 3.1803962455e+06
R_Dense_2_23_8 L1_N23 L2_N8 1.0688917890e+05
R_Dense_2_24_8 L1_N24 L2_N8 2.6750689922e+05
R_Dense_2_25_8 L1_N25 L2_N8 3.4128806185e+05
R_Dense_2_26_8 L1_N26 L2_N8 1.1579098721e+05
R_Dense_2_27_8 L1_N27 L2_N8 1.6518916768e+05
R_Dense_2_28_8 L1_N28 L2_N8 1.2751136143e+05
R_Dense_2_29_8 L1_N29 L2_N8 1.9216864410e+05
R_Dense_2_30_8 L1_N30 L2_N8 1.2451452270e+05
R_Dense_2_31_8 L1_N31 L2_N8 1.3843991856e+05
R_Dense_2_32_8 L1_N32 L2_N8 2.5264229395e+05
R_Dense_2_33_8 L1_N33 L2_N8 2.2713241051e+05
R_Dense_2_34_8 L1_N34 L2_N8 1.1886923895e+05
R_Dense_2_35_8 L1_N35 L2_N8 2.7793177036e+05
R_Dense_2_36_8 L1_N36 L2_N8 4.4955212577e+06
R_Dense_2_37_8 L1_N37 L2_N8 1.9841893917e+05
R_Dense_2_38_8 L1_N38 L2_N8 9.4747446106e+05
R_Dense_2_39_8 L1_N39 L2_N8 1.2457755254e+05
R_Dense_2_40_8 L1_N40 L2_N8 2.5238911994e+05
R_Dense_2_41_8 L1_N41 L2_N8 2.0784986434e+05
R_Dense_2_42_8 L1_N42 L2_N8 1.2026642972e+05
R_Dense_2_43_8 L1_N43 L2_N8 1.6851351059e+05
R_Dense_2_44_8 L1_N44 L2_N8 1.7899915675e+05
R_Dense_2_45_8 L1_N45 L2_N8 1.4253214473e+05
R_Dense_2_46_8 L1_N46 L2_N8 1.1855637022e+05
R_Dense_2_47_8 L1_N47 L2_N8 1.8087782513e+06
R_Dense_2_48_8 L1_N48 L2_N8 3.9296117304e+05
R_Dense_2_49_8 L1_N49 L2_N8 1.9040320597e+05
R_Dense_2_50_8 L1_N50 L2_N8 8.8660488483e+06
R_Dense_2_51_8 L1_N51 L2_N8 1.2879292247e+05
R_Dense_2_52_8 L1_N52 L2_N8 2.9217630770e+05
R_Dense_2_53_8 L1_N53 L2_N8 8.0030673050e+05
R_Dense_2_54_8 L1_N54 L2_N8 1.2816140540e+05
R_Dense_2_55_8 L1_N55 L2_N8 2.0381266604e+05
R_Dense_2_56_8 L1_N56 L2_N8 1.5778652988e+05
R_Dense_2_57_8 L1_N57 L2_N8 2.1632541974e+05
R_Dense_2_58_8 L1_N58 L2_N8 1.7819288473e+05
R_Dense_2_59_8 L1_N59 L2_N8 1.2377684083e+05
R_Dense_2_60_8 L1_N60 L2_N8 1.2951625364e+05
R_Dense_2_61_8 L1_N61 L2_N8 1.2432957831e+05
R_Dense_2_62_8 L1_N62 L2_N8 1.3686884879e+05
R_Dense_2_63_8 L1_N63 L2_N8 1.4027460645e+05
R_Dense_2_64_8 L1_N64 L2_N8 1.0503553507e+05
R_Dense_2_65_8 L1_N65 L2_N8 1.1973878095e+05
R_Dense_2_66_8 L1_N66 L2_N8 2.1199549922e+05
R_Dense_2_67_8 L1_N67 L2_N8 3.1139002036e+05
R_Dense_2_68_8 L1_N68 L2_N8 1.3775864706e+05
R_Dense_2_69_8 L1_N69 L2_N8 3.2662853071e+05
R_Dense_2_70_8 L1_N70 L2_N8 8.0268651849e+05
R_Dense_2_71_8 L1_N71 L2_N8 2.7012650221e+05
R_Dense_2_72_8 L1_N72 L2_N8 1.1042663492e+05
R_Dense_2_73_8 L1_N73 L2_N8 1.2304396176e+05
R_Dense_2_74_8 L1_N74 L2_N8 6.1246017314e+05
R_Dense_2_75_8 L1_N75 L2_N8 1.7610681231e+06
R_Dense_2_76_8 L1_N76 L2_N8 1.7176324209e+05
R_Dense_2_77_8 L1_N77 L2_N8 3.8600711955e+05
R_Dense_2_78_8 L1_N78 L2_N8 6.8159874930e+05
R_Dense_2_79_8 L1_N79 L2_N8 1.2256627504e+05
R_Dense_2_80_8 L1_N80 L2_N8 1.1252734309e+05
R_Dense_2_81_8 L1_N81 L2_N8 4.5777750121e+05
R_Dense_2_82_8 L1_N82 L2_N8 2.2279346621e+05
R_Dense_2_83_8 L1_N83 L2_N8 8.0602221765e+05
R_Dense_2_84_8 L1_N84 L2_N8 1.0664780494e+05
R_Dense_2_85_8 L1_N85 L2_N8 4.3494402650e+05
R_Dense_2_86_8 L1_N86 L2_N8 2.8329183222e+05
R_Dense_2_87_8 L1_N87 L2_N8 5.6393521148e+06
R_Dense_2_88_8 L1_N88 L2_N8 1.0608328321e+05
R_Dense_2_89_8 L1_N89 L2_N8 1.7051447360e+05
R_Dense_2_90_8 L1_N90 L2_N8 2.9047731659e+05
R_Dense_2_91_8 L1_N91 L2_N8 2.6110695319e+05
R_Dense_2_92_8 L1_N92 L2_N8 1.5892590074e+05
R_Dense_2_93_8 L1_N93 L2_N8 1.1282305108e+05
R_Dense_2_94_8 L1_N94 L2_N8 3.0495632220e+05
R_Dense_2_95_8 L1_N95 L2_N8 1.6611443552e+05
R_Dense_2_96_8 L1_N96 L2_N8 1.3774001802e+05
R_Dense_2_97_8 L1_N97 L2_N8 3.4468088488e+05
R_Dense_2_98_8 L1_N98 L2_N8 1.7704763614e+05
R_Dense_2_99_8 L1_N99 L2_N8 1.5379400025e+05
R_Dense_2_100_8 L1_N100 L2_N8 1.0241209533e+05
R_Dense_2_101_8 L1_N101 L2_N8 1.6732455322e+05
R_Dense_2_102_8 L1_N102 L2_N8 1.6211214183e+05
R_Dense_2_103_8 L1_N103 L2_N8 4.0689928520e+05
R_Dense_2_104_8 L1_N104 L2_N8 2.1384513674e+05
R_Dense_2_105_8 L1_N105 L2_N8 1.6593283108e+05
R_Dense_2_106_8 L1_N106 L2_N8 1.3494045930e+05
R_Dense_2_107_8 L1_N107 L2_N8 2.5973019274e+05
R_Dense_2_108_8 L1_N108 L2_N8 1.0359267570e+05
R_Dense_2_109_8 L1_N109 L2_N8 1.5832292205e+05
R_Dense_2_110_8 L1_N110 L2_N8 1.8735127578e+05
R_Dense_2_111_8 L1_N111 L2_N8 2.4860903789e+05
R_Dense_2_112_8 L1_N112 L2_N8 1.2048883974e+05
R_Dense_2_113_8 L1_N113 L2_N8 3.4035488223e+05
R_Dense_2_114_8 L1_N114 L2_N8 2.1177085912e+05
R_Dense_2_115_8 L1_N115 L2_N8 4.5203857569e+05
R_Dense_2_116_8 L1_N116 L2_N8 1.4759015975e+05
R_Dense_2_117_8 L1_N117 L2_N8 1.4622610649e+05
R_Dense_2_118_8 L1_N118 L2_N8 6.2303597484e+05
R_Dense_2_119_8 L1_N119 L2_N8 2.2943034876e+05
R_Dense_2_120_8 L1_N120 L2_N8 1.3174464986e+05
R_Dense_2_121_8 L1_N121 L2_N8 6.5008259800e+05
R_Dense_2_122_8 L1_N122 L2_N8 1.0377173709e+06
R_Dense_2_123_8 L1_N123 L2_N8 1.4772009714e+05
R_Dense_2_124_8 L1_N124 L2_N8 2.1103944925e+05
R_Dense_2_125_8 L1_N125 L2_N8 1.3504617869e+05
R_Dense_2_126_8 L1_N126 L2_N8 1.5076628585e+05
R_Dense_2_127_8 L1_N127 L2_N8 1.0640901145e+05
R_Dense_2_128_8 L1_N128 L2_N8 1.6428292455e+05
R_Dense_2_129_8 L1_N129 L2_N8 2.6954442156e+05
R_Dense_2_130_8 L1_N130 L2_N8 4.3286274458e+05
R_Dense_2_131_8 L1_N131 L2_N8 1.8603595421e+05
R_Dense_2_132_8 L1_N132 L2_N8 2.3290686734e+05
R_Dense_2_133_8 L1_N133 L2_N8 1.2321842909e+06
R_Dense_2_134_8 L1_N134 L2_N8 1.1792793605e+05
R_Dense_2_135_8 L1_N135 L2_N8 1.1997921528e+05
R_Dense_2_136_8 L1_N136 L2_N8 5.2475925844e+05
R_Dense_2_137_8 L1_N137 L2_N8 3.9687944321e+05
R_Dense_2_138_8 L1_N138 L2_N8 7.7334319295e+05
R_Dense_2_139_8 L1_N139 L2_N8 8.9751867713e+05
R_Dense_2_140_8 L1_N140 L2_N8 3.0614251573e+05
R_Dense_2_141_8 L1_N141 L2_N8 3.1895369124e+05
R_Dense_2_142_8 L1_N142 L2_N8 9.3695400349e+05
R_Dense_2_143_8 L1_N143 L2_N8 7.8870401106e+05
R_Dense_2_144_8 L1_N144 L2_N8 1.4004861766e+05
R_Dense_2_145_8 L1_N145 L2_N8 1.3498568446e+05
R_Dense_2_146_8 L1_N146 L2_N8 4.7853841738e+05
R_Dense_2_147_8 L1_N147 L2_N8 1.4938181125e+05
R_Dense_2_148_8 L1_N148 L2_N8 2.9127063095e+06
R_Dense_2_149_8 L1_N149 L2_N8 1.1866114334e+05
R_Dense_2_150_8 L1_N150 L2_N8 1.9708671144e+05
R_Dense_2_151_8 L1_N151 L2_N8 2.1378587787e+05
R_Dense_2_152_8 L1_N152 L2_N8 4.5379852151e+05
R_Dense_2_153_8 L1_N153 L2_N8 2.5869411218e+05
R_Dense_2_154_8 L1_N154 L2_N8 1.3823956020e+05
R_Dense_2_155_8 L1_N155 L2_N8 1.7048514969e+05
R_Dense_2_156_8 L1_N156 L2_N8 5.8880736334e+05
R_Dense_2_157_8 L1_N157 L2_N8 1.1513551159e+05
R_Dense_2_158_8 L1_N158 L2_N8 7.6262063905e+05
R_Dense_2_159_8 L1_N159 L2_N8 1.7396071138e+05
R_Dense_2_160_8 L1_N160 L2_N8 9.0294338719e+05
R_Dense_2_161_8 L1_N161 L2_N8 5.9983938751e+05
R_Dense_2_162_8 L1_N162 L2_N8 2.3676434818e+05
R_Dense_2_163_8 L1_N163 L2_N8 1.2136862363e+05
R_Dense_2_164_8 L1_N164 L2_N8 1.3948363508e+05
R_Dense_2_165_8 L1_N165 L2_N8 2.4695242168e+05
R_Dense_2_166_8 L1_N166 L2_N8 1.9975618673e+05
R_Dense_2_167_8 L1_N167 L2_N8 3.3288992379e+05
R_Dense_2_168_8 L1_N168 L2_N8 1.4472829283e+05
R_Dense_2_169_8 L1_N169 L2_N8 2.8421569035e+05
R_Dense_2_170_8 L1_N170 L2_N8 2.1237556725e+05
R_Dense_2_171_8 L1_N171 L2_N8 3.2816897314e+05
R_Dense_2_172_8 L1_N172 L2_N8 2.8024033171e+05
R_Dense_2_173_8 L1_N173 L2_N8 1.9037381221e+06
R_Dense_2_174_8 L1_N174 L2_N8 2.7752817646e+05
R_Dense_2_175_8 L1_N175 L2_N8 4.1324503617e+05
R_Dense_2_176_8 L1_N176 L2_N8 1.2287967374e+05
R_Dense_2_177_8 L1_N177 L2_N8 2.0256420085e+05
R_Dense_2_178_8 L1_N178 L2_N8 2.3535947623e+05
R_Dense_2_179_8 L1_N179 L2_N8 3.4906223843e+05
R_Dense_2_180_8 L1_N180 L2_N8 3.6380811801e+05
R_Dense_2_181_8 L1_N181 L2_N8 1.5935135578e+05
R_Dense_2_182_8 L1_N182 L2_N8 1.0988918647e+06
R_Dense_2_183_8 L1_N183 L2_N8 1.6919770786e+05
R_Dense_2_184_8 L1_N184 L2_N8 1.5363440697e+05
R_Dense_2_185_8 L1_N185 L2_N8 2.3888333889e+05
R_Dense_2_186_8 L1_N186 L2_N8 3.3150608537e+05
R_Dense_2_187_8 L1_N187 L2_N8 1.5439242558e+05
R_Dense_2_188_8 L1_N188 L2_N8 1.0969482673e+05
R_Dense_2_189_8 L1_N189 L2_N8 2.4815093860e+05
R_Dense_2_190_8 L1_N190 L2_N8 2.3721411182e+06
R_Dense_2_191_8 L1_N191 L2_N8 5.3757325694e+05
R_Dense_2_192_8 L1_N192 L2_N8 1.7497596849e+05
R_Dense_2_193_8 L1_N193 L2_N8 2.5104599079e+05
R_Dense_2_194_8 L1_N194 L2_N8 1.5617498728e+05
R_Dense_2_195_8 L1_N195 L2_N8 1.6562113774e+05
R_Dense_2_196_8 L1_N196 L2_N8 2.3308426804e+05
R_Dense_2_197_8 L1_N197 L2_N8 1.1644775112e+05
R_Dense_2_198_8 L1_N198 L2_N8 8.4988851972e+05
R_Dense_2_199_8 L1_N199 L2_N8 5.9744739565e+05
R_Dense_2_200_8 L1_N200 L2_N8 7.6029298523e+05
R_Dense_2_201_8 L1_N201 L2_N8 1.5116190305e+05
R_Dense_2_202_8 L1_N202 L2_N8 4.1738986821e+05
R_Dense_2_203_8 L1_N203 L2_N8 2.9932557546e+06
R_Dense_2_204_8 L1_N204 L2_N8 1.7224186495e+05
R_Dense_2_205_8 L1_N205 L2_N8 1.0587060420e+05
R_Dense_2_206_8 L1_N206 L2_N8 5.6227690357e+05
R_Dense_2_207_8 L1_N207 L2_N8 1.0017998510e+05
R_Dense_2_208_8 L1_N208 L2_N8 4.6621186465e+05
R_Dense_2_209_8 L1_N209 L2_N8 1.0279979998e+06
R_Dense_2_210_8 L1_N210 L2_N8 4.2288937580e+05
R_Dense_2_211_8 L1_N211 L2_N8 1.8750194244e+05
R_Dense_2_212_8 L1_N212 L2_N8 1.3602915204e+06
R_Dense_2_213_8 L1_N213 L2_N8 4.1577502456e+05
R_Dense_2_214_8 L1_N214 L2_N8 4.4978674408e+05
R_Dense_2_215_8 L1_N215 L2_N8 4.4672134567e+05
R_Dense_2_216_8 L1_N216 L2_N8 1.3807229183e+05
R_Dense_2_217_8 L1_N217 L2_N8 3.0109141372e+05
R_Dense_2_218_8 L1_N218 L2_N8 2.3515376789e+05
R_Dense_2_219_8 L1_N219 L2_N8 2.0160909317e+06
R_Dense_2_220_8 L1_N220 L2_N8 3.4218136983e+05
R_Dense_2_221_8 L1_N221 L2_N8 9.0758436597e+05
R_Dense_2_222_8 L1_N222 L2_N8 5.3922552327e+05
R_Dense_2_223_8 L1_N223 L2_N8 3.2593912151e+05
R_Dense_2_224_8 L1_N224 L2_N8 1.6479717254e+05
R_Dense_2_225_8 L1_N225 L2_N8 1.9747192519e+05
R_Dense_2_226_8 L1_N226 L2_N8 8.5656004382e+05
R_Dense_2_227_8 L1_N227 L2_N8 6.9114273176e+05
R_Dense_2_228_8 L1_N228 L2_N8 1.5344264358e+05
R_Dense_2_229_8 L1_N229 L2_N8 2.1975659421e+05
R_Dense_2_230_8 L1_N230 L2_N8 1.4530799870e+05
R_Dense_2_231_8 L1_N231 L2_N8 2.7101529356e+05
R_Dense_2_232_8 L1_N232 L2_N8 1.3031496914e+05
R_Dense_2_233_8 L1_N233 L2_N8 1.9301313204e+05
R_Dense_2_234_8 L1_N234 L2_N8 1.3892063454e+06
R_Dense_2_235_8 L1_N235 L2_N8 1.9519939604e+05
R_Dense_2_236_8 L1_N236 L2_N8 3.3373698322e+05
R_Dense_2_237_8 L1_N237 L2_N8 2.1249221589e+05
R_Dense_2_238_8 L1_N238 L2_N8 2.3361836978e+05
R_Dense_2_239_8 L1_N239 L2_N8 1.2213811994e+05
R_Dense_2_240_8 L1_N240 L2_N8 1.4149336038e+05
R_Dense_2_241_8 L1_N241 L2_N8 1.8177166568e+05
R_Dense_2_242_8 L1_N242 L2_N8 1.0313830824e+05
R_Dense_2_243_8 L1_N243 L2_N8 4.7648341163e+05
R_Dense_2_244_8 L1_N244 L2_N8 2.9551344633e+05
R_Dense_2_245_8 L1_N245 L2_N8 6.9213710186e+05
R_Dense_2_246_8 L1_N246 L2_N8 5.2866801471e+05
R_Dense_2_247_8 L1_N247 L2_N8 3.3551582790e+06
R_Dense_2_248_8 L1_N248 L2_N8 1.2189683666e+05
R_Dense_2_249_8 L1_N249 L2_N8 2.8035910152e+05
R_Dense_2_250_8 L1_N250 L2_N8 1.2306464149e+06
R_Dense_2_251_8 L1_N251 L2_N8 2.0476214431e+05
R_Dense_2_252_8 L1_N252 L2_N8 2.2297740657e+05
R_Dense_2_253_8 L1_N253 L2_N8 1.0919146826e+05
R_Dense_2_254_8 L1_N254 L2_N8 2.5121891731e+05
R_Dense_2_255_8 L1_N255 L2_N8 7.0274491773e+05
R_Dense_2_256_8 L1_N256 L2_N8 2.3609221001e+05
R_Dense_2_257_8 L1_N257 L2_N8 1.0615475681e+05
R_Dense_2_258_8 L1_N258 L2_N8 2.7634683735e+05
R_Dense_2_259_8 L1_N259 L2_N8 4.6453979161e+05
R_Dense_2_260_8 L1_N260 L2_N8 1.0615709761e+05
R_Dense_2_261_8 L1_N261 L2_N8 1.2291558799e+05
R_Dense_2_262_8 L1_N262 L2_N8 1.0399740252e+05
R_Dense_2_263_8 L1_N263 L2_N8 1.1485975793e+05
R_Dense_2_264_8 L1_N264 L2_N8 1.1416253177e+05
R_Dense_2_265_8 L1_N265 L2_N8 2.8061095782e+05
R_Dense_2_266_8 L1_N266 L2_N8 1.2837885591e+06
R_Dense_2_267_8 L1_N267 L2_N8 1.2033167902e+05
R_Dense_2_268_8 L1_N268 L2_N8 1.2974385420e+05
R_Dense_2_269_8 L1_N269 L2_N8 2.3132997491e+05
R_Dense_2_270_8 L1_N270 L2_N8 2.2459943050e+05
R_Dense_2_271_8 L1_N271 L2_N8 3.9052429495e+05
R_Dense_2_272_8 L1_N272 L2_N8 4.0948944282e+05
R_Dense_2_273_8 L1_N273 L2_N8 5.1699238703e+05
R_Dense_2_274_8 L1_N274 L2_N8 1.1516349236e+05
R_Dense_2_275_8 L1_N275 L2_N8 3.5761127011e+06
R_Dense_2_276_8 L1_N276 L2_N8 1.1849687588e+05
R_Dense_2_277_8 L1_N277 L2_N8 3.7415221686e+05
R_Dense_2_278_8 L1_N278 L2_N8 3.3255585778e+06
R_Dense_2_279_8 L1_N279 L2_N8 6.8405230628e+05
R_Dense_2_280_8 L1_N280 L2_N8 3.0651343452e+05
R_Dense_2_281_8 L1_N281 L2_N8 2.1478629982e+05
R_Dense_2_282_8 L1_N282 L2_N8 1.4317265829e+05
R_Dense_2_283_8 L1_N283 L2_N8 1.7620755067e+05
R_Dense_2_284_8 L1_N284 L2_N8 3.9974203977e+05
R_Dense_2_285_8 L1_N285 L2_N8 2.6303549908e+05
R_Dense_2_286_8 L1_N286 L2_N8 1.4296789972e+05
R_Dense_2_287_8 L1_N287 L2_N8 5.4963110862e+05
R_Dense_2_288_8 L1_N288 L2_N8 2.1660728231e+05
R_Dense_2_289_8 L1_N289 L2_N8 1.5342026401e+05
R_Dense_2_290_8 L1_N290 L2_N8 2.2515974080e+06
R_Dense_2_291_8 L1_N291 L2_N8 1.0239302428e+05
R_Dense_2_292_8 L1_N292 L2_N8 3.0909545526e+05
R_Dense_2_293_8 L1_N293 L2_N8 3.2113900676e+05
R_Dense_2_294_8 L1_N294 L2_N8 4.1999423312e+05
R_Dense_2_295_8 L1_N295 L2_N8 3.7332638394e+05
R_Dense_2_296_8 L1_N296 L2_N8 1.8877193493e+05
R_Dense_2_297_8 L1_N297 L2_N8 1.5493117581e+05
R_Dense_2_298_8 L1_N298 L2_N8 1.6460035139e+05
R_Dense_2_299_8 L1_N299 L2_N8 2.4167223881e+05
R_Dense_2_300_8 L1_N300 L2_N8 1.7114502139e+05
R_Dense_2_301_8 L1_N301 L2_N8 1.8549037537e+05
R_Dense_2_302_8 L1_N302 L2_N8 1.7881965031e+05
R_Dense_2_303_8 L1_N303 L2_N8 2.8538637579e+05
R_Dense_2_304_8 L1_N304 L2_N8 1.1932207138e+05
R_Dense_2_305_8 L1_N305 L2_N8 1.5101208748e+05
R_Dense_2_306_8 L1_N306 L2_N8 1.5618907721e+05
R_Dense_2_307_8 L1_N307 L2_N8 1.3847421702e+05
R_Dense_2_308_8 L1_N308 L2_N8 2.0763192671e+05
R_Dense_2_309_8 L1_N309 L2_N8 1.4698833122e+05
R_Dense_2_310_8 L1_N310 L2_N8 1.2146386736e+05
R_Dense_2_311_8 L1_N311 L2_N8 1.0770342040e+05
R_Dense_2_312_8 L1_N312 L2_N8 1.4647077901e+05
R_Dense_2_313_8 L1_N313 L2_N8 3.2949035344e+05
R_Dense_2_314_8 L1_N314 L2_N8 2.2912959736e+05
R_Dense_2_315_8 L1_N315 L2_N8 1.3318713040e+05
R_Dense_2_316_8 L1_N316 L2_N8 1.0971645920e+05
R_Dense_2_317_8 L1_N317 L2_N8 1.1876444147e+05
R_Dense_2_318_8 L1_N318 L2_N8 3.8764647725e+05
R_Dense_2_319_8 L1_N319 L2_N8 1.3112317955e+06
R_Dense_2_320_8 L1_N320 L2_N8 1.4980130786e+06
R_Dense_2_321_8 L1_N321 L2_N8 1.3295638615e+05
R_Dense_2_322_8 L1_N322 L2_N8 2.9805167025e+05
R_Dense_2_323_8 L1_N323 L2_N8 1.2663634859e+05
R_Dense_2_324_8 L1_N324 L2_N8 2.1102439397e+05
R_Dense_2_325_8 L1_N325 L2_N8 2.2055106119e+05
R_Dense_2_326_8 L1_N326 L2_N8 1.1204702637e+05
R_Dense_2_327_8 L1_N327 L2_N8 8.4103404040e+05
R_Dense_2_328_8 L1_N328 L2_N8 2.0356696569e+05
R_Dense_2_329_8 L1_N329 L2_N8 4.8433795785e+05
R_Dense_2_330_8 L1_N330 L2_N8 3.1654240038e+05
R_Dense_2_331_8 L1_N331 L2_N8 2.3956552446e+05
R_Dense_2_332_8 L1_N332 L2_N8 1.1392462437e+05
R_Dense_2_333_8 L1_N333 L2_N8 1.1062442043e+05
R_Dense_2_334_8 L1_N334 L2_N8 3.9338379223e+05
R_Dense_2_335_8 L1_N335 L2_N8 5.0513050347e+05
R_Dense_2_336_8 L1_N336 L2_N8 1.0395080775e+05
R_Dense_2_337_8 L1_N337 L2_N8 1.4579194717e+05
*
R_Dense_2_0_9 L1_N0 L2_N9 1.8536747259e+05
R_Dense_2_1_9 L1_N1 L2_N9 1.0938066130e+05
R_Dense_2_2_9 L1_N2 L2_N9 1.2534159321e+05
R_Dense_2_3_9 L1_N3 L2_N9 3.6894437565e+05
R_Dense_2_4_9 L1_N4 L2_N9 2.2777867193e+05
R_Dense_2_5_9 L1_N5 L2_N9 3.3343966213e+05
R_Dense_2_6_9 L1_N6 L2_N9 3.7156237928e+05
R_Dense_2_7_9 L1_N7 L2_N9 1.5200489906e+05
R_Dense_2_8_9 L1_N8 L2_N9 1.3750570291e+05
R_Dense_2_9_9 L1_N9 L2_N9 2.2583336701e+05
R_Dense_2_10_9 L1_N10 L2_N9 2.5576826159e+05
R_Dense_2_11_9 L1_N11 L2_N9 9.0487198932e+05
R_Dense_2_12_9 L1_N12 L2_N9 1.8464340345e+05
R_Dense_2_13_9 L1_N13 L2_N9 1.8431147269e+05
R_Dense_2_14_9 L1_N14 L2_N9 1.9340538048e+05
R_Dense_2_15_9 L1_N15 L2_N9 1.6039655958e+05
R_Dense_2_16_9 L1_N16 L2_N9 7.6396274873e+05
R_Dense_2_17_9 L1_N17 L2_N9 1.1849761498e+05
R_Dense_2_18_9 L1_N18 L2_N9 2.0261774542e+06
R_Dense_2_19_9 L1_N19 L2_N9 1.3746580763e+05
R_Dense_2_20_9 L1_N20 L2_N9 1.4758351656e+05
R_Dense_2_21_9 L1_N21 L2_N9 1.2555121944e+05
R_Dense_2_22_9 L1_N22 L2_N9 1.0675361227e+05
R_Dense_2_23_9 L1_N23 L2_N9 8.9504129237e+05
R_Dense_2_24_9 L1_N24 L2_N9 1.5196774880e+05
R_Dense_2_25_9 L1_N25 L2_N9 1.0257800831e+05
R_Dense_2_26_9 L1_N26 L2_N9 2.1214340208e+05
R_Dense_2_27_9 L1_N27 L2_N9 4.3074206039e+05
R_Dense_2_28_9 L1_N28 L2_N9 1.3097673921e+05
R_Dense_2_29_9 L1_N29 L2_N9 1.0437990119e+05
R_Dense_2_30_9 L1_N30 L2_N9 2.9337685784e+05
R_Dense_2_31_9 L1_N31 L2_N9 1.1550381305e+05
R_Dense_2_32_9 L1_N32 L2_N9 1.1372089126e+05
R_Dense_2_33_9 L1_N33 L2_N9 3.9300893498e+05
R_Dense_2_34_9 L1_N34 L2_N9 1.2633731246e+06
R_Dense_2_35_9 L1_N35 L2_N9 1.0581601821e+05
R_Dense_2_36_9 L1_N36 L2_N9 2.1831377234e+05
R_Dense_2_37_9 L1_N37 L2_N9 1.4029816330e+05
R_Dense_2_38_9 L1_N38 L2_N9 1.9357546503e+05
R_Dense_2_39_9 L1_N39 L2_N9 2.8409884320e+05
R_Dense_2_40_9 L1_N40 L2_N9 1.0942584843e+05
R_Dense_2_41_9 L1_N41 L2_N9 2.0843112015e+05
R_Dense_2_42_9 L1_N42 L2_N9 1.9229318776e+05
R_Dense_2_43_9 L1_N43 L2_N9 2.4156596248e+05
R_Dense_2_44_9 L1_N44 L2_N9 2.3012274281e+05
R_Dense_2_45_9 L1_N45 L2_N9 1.2153235288e+05
R_Dense_2_46_9 L1_N46 L2_N9 2.7121102847e+05
R_Dense_2_47_9 L1_N47 L2_N9 5.7094033000e+05
R_Dense_2_48_9 L1_N48 L2_N9 1.1058818370e+05
R_Dense_2_49_9 L1_N49 L2_N9 1.3266318970e+05
R_Dense_2_50_9 L1_N50 L2_N9 1.2872603292e+05
R_Dense_2_51_9 L1_N51 L2_N9 1.3138803085e+05
R_Dense_2_52_9 L1_N52 L2_N9 3.5610425600e+05
R_Dense_2_53_9 L1_N53 L2_N9 2.5716233899e+05
R_Dense_2_54_9 L1_N54 L2_N9 1.8569008913e+05
R_Dense_2_55_9 L1_N55 L2_N9 4.0686925092e+05
R_Dense_2_56_9 L1_N56 L2_N9 1.7918056258e+05
R_Dense_2_57_9 L1_N57 L2_N9 1.0972330885e+05
R_Dense_2_58_9 L1_N58 L2_N9 8.6994466528e+05
R_Dense_2_59_9 L1_N59 L2_N9 4.2107965841e+05
R_Dense_2_60_9 L1_N60 L2_N9 3.2232876171e+05
R_Dense_2_61_9 L1_N61 L2_N9 7.1740147581e+05
R_Dense_2_62_9 L1_N62 L2_N9 3.0415368318e+05
R_Dense_2_63_9 L1_N63 L2_N9 2.7142719980e+05
R_Dense_2_64_9 L1_N64 L2_N9 1.3484099442e+06
R_Dense_2_65_9 L1_N65 L2_N9 1.0817819981e+05
R_Dense_2_66_9 L1_N66 L2_N9 2.0079123250e+05
R_Dense_2_67_9 L1_N67 L2_N9 1.5247829699e+05
R_Dense_2_68_9 L1_N68 L2_N9 2.5242130231e+05
R_Dense_2_69_9 L1_N69 L2_N9 4.3154290141e+05
R_Dense_2_70_9 L1_N70 L2_N9 1.0488421421e+05
R_Dense_2_71_9 L1_N71 L2_N9 1.5920955297e+05
R_Dense_2_72_9 L1_N72 L2_N9 9.6411447676e+05
R_Dense_2_73_9 L1_N73 L2_N9 1.3466408859e+05
R_Dense_2_74_9 L1_N74 L2_N9 8.6516424630e+05
R_Dense_2_75_9 L1_N75 L2_N9 2.4276244596e+05
R_Dense_2_76_9 L1_N76 L2_N9 1.3931384310e+06
R_Dense_2_77_9 L1_N77 L2_N9 4.0073486054e+05
R_Dense_2_78_9 L1_N78 L2_N9 1.1578730228e+05
R_Dense_2_79_9 L1_N79 L2_N9 3.4043340120e+05
R_Dense_2_80_9 L1_N80 L2_N9 1.5608440573e+05
R_Dense_2_81_9 L1_N81 L2_N9 2.1352941350e+05
R_Dense_2_82_9 L1_N82 L2_N9 6.2982221415e+05
R_Dense_2_83_9 L1_N83 L2_N9 2.3118807924e+05
R_Dense_2_84_9 L1_N84 L2_N9 2.5414836863e+05
R_Dense_2_85_9 L1_N85 L2_N9 2.3518868358e+06
R_Dense_2_86_9 L1_N86 L2_N9 4.6049175184e+05
R_Dense_2_87_9 L1_N87 L2_N9 1.6269510213e+05
R_Dense_2_88_9 L1_N88 L2_N9 1.1295724305e+05
R_Dense_2_89_9 L1_N89 L2_N9 3.7298037700e+05
R_Dense_2_90_9 L1_N90 L2_N9 2.2059605763e+05
R_Dense_2_91_9 L1_N91 L2_N9 5.0252689278e+05
R_Dense_2_92_9 L1_N92 L2_N9 3.3665811120e+05
R_Dense_2_93_9 L1_N93 L2_N9 2.0464774269e+06
R_Dense_2_94_9 L1_N94 L2_N9 1.4247969567e+06
R_Dense_2_95_9 L1_N95 L2_N9 3.5340225572e+05
R_Dense_2_96_9 L1_N96 L2_N9 1.7595505081e+05
R_Dense_2_97_9 L1_N97 L2_N9 3.0731498059e+05
R_Dense_2_98_9 L1_N98 L2_N9 1.2357995783e+05
R_Dense_2_99_9 L1_N99 L2_N9 7.3005998124e+05
R_Dense_2_100_9 L1_N100 L2_N9 4.5781011107e+05
R_Dense_2_101_9 L1_N101 L2_N9 5.6988508015e+05
R_Dense_2_102_9 L1_N102 L2_N9 1.2039473589e+05
R_Dense_2_103_9 L1_N103 L2_N9 1.4000984941e+05
R_Dense_2_104_9 L1_N104 L2_N9 1.9681697121e+05
R_Dense_2_105_9 L1_N105 L2_N9 1.0006883966e+05
R_Dense_2_106_9 L1_N106 L2_N9 1.7648379030e+06
R_Dense_2_107_9 L1_N107 L2_N9 1.1827446553e+05
R_Dense_2_108_9 L1_N108 L2_N9 1.2460127870e+05
R_Dense_2_109_9 L1_N109 L2_N9 2.2616480739e+05
R_Dense_2_110_9 L1_N110 L2_N9 1.8160852921e+05
R_Dense_2_111_9 L1_N111 L2_N9 3.3189722743e+05
R_Dense_2_112_9 L1_N112 L2_N9 5.8282998832e+05
R_Dense_2_113_9 L1_N113 L2_N9 1.9965926508e+05
R_Dense_2_114_9 L1_N114 L2_N9 2.9500871641e+05
R_Dense_2_115_9 L1_N115 L2_N9 1.0593015709e+05
R_Dense_2_116_9 L1_N116 L2_N9 1.2032281431e+05
R_Dense_2_117_9 L1_N117 L2_N9 1.0218254531e+06
R_Dense_2_118_9 L1_N118 L2_N9 1.3606927497e+05
R_Dense_2_119_9 L1_N119 L2_N9 1.9211313238e+05
R_Dense_2_120_9 L1_N120 L2_N9 1.0770630367e+05
R_Dense_2_121_9 L1_N121 L2_N9 1.5804950638e+06
R_Dense_2_122_9 L1_N122 L2_N9 2.4024945854e+05
R_Dense_2_123_9 L1_N123 L2_N9 5.7701110882e+06
R_Dense_2_124_9 L1_N124 L2_N9 3.2680905033e+05
R_Dense_2_125_9 L1_N125 L2_N9 1.4292846290e+05
R_Dense_2_126_9 L1_N126 L2_N9 2.1931423569e+05
R_Dense_2_127_9 L1_N127 L2_N9 5.6924943364e+05
R_Dense_2_128_9 L1_N128 L2_N9 1.1266156589e+06
R_Dense_2_129_9 L1_N129 L2_N9 1.1173680515e+05
R_Dense_2_130_9 L1_N130 L2_N9 3.0760179196e+05
R_Dense_2_131_9 L1_N131 L2_N9 1.4834762389e+05
R_Dense_2_132_9 L1_N132 L2_N9 9.9299373847e+05
R_Dense_2_133_9 L1_N133 L2_N9 1.2625237915e+05
R_Dense_2_134_9 L1_N134 L2_N9 3.4106639251e+05
R_Dense_2_135_9 L1_N135 L2_N9 5.4572486412e+05
R_Dense_2_136_9 L1_N136 L2_N9 1.8188275771e+05
R_Dense_2_137_9 L1_N137 L2_N9 1.5401947521e+05
R_Dense_2_138_9 L1_N138 L2_N9 1.3742923174e+05
R_Dense_2_139_9 L1_N139 L2_N9 3.1262949691e+05
R_Dense_2_140_9 L1_N140 L2_N9 2.2676921155e+05
R_Dense_2_141_9 L1_N141 L2_N9 1.1247956764e+05
R_Dense_2_142_9 L1_N142 L2_N9 1.5811654323e+05
R_Dense_2_143_9 L1_N143 L2_N9 1.2295699250e+05
R_Dense_2_144_9 L1_N144 L2_N9 1.1211340938e+05
R_Dense_2_145_9 L1_N145 L2_N9 1.8661273538e+06
R_Dense_2_146_9 L1_N146 L2_N9 1.1295275808e+05
R_Dense_2_147_9 L1_N147 L2_N9 1.4628745624e+05
R_Dense_2_148_9 L1_N148 L2_N9 1.0339349705e+05
R_Dense_2_149_9 L1_N149 L2_N9 2.2289861799e+05
R_Dense_2_150_9 L1_N150 L2_N9 1.2281727379e+05
R_Dense_2_151_9 L1_N151 L2_N9 2.7212348306e+05
R_Dense_2_152_9 L1_N152 L2_N9 1.7308951736e+05
R_Dense_2_153_9 L1_N153 L2_N9 1.1027073407e+05
R_Dense_2_154_9 L1_N154 L2_N9 1.0665816870e+05
R_Dense_2_155_9 L1_N155 L2_N9 1.9266926143e+05
R_Dense_2_156_9 L1_N156 L2_N9 4.1658567256e+05
R_Dense_2_157_9 L1_N157 L2_N9 1.1821996006e+05
R_Dense_2_158_9 L1_N158 L2_N9 4.8017395032e+05
R_Dense_2_159_9 L1_N159 L2_N9 1.4635390579e+05
R_Dense_2_160_9 L1_N160 L2_N9 1.6254683559e+05
R_Dense_2_161_9 L1_N161 L2_N9 2.0361561172e+05
R_Dense_2_162_9 L1_N162 L2_N9 1.0284770429e+05
R_Dense_2_163_9 L1_N163 L2_N9 1.7814882221e+05
R_Dense_2_164_9 L1_N164 L2_N9 3.7177612182e+05
R_Dense_2_165_9 L1_N165 L2_N9 1.7991036561e+06
R_Dense_2_166_9 L1_N166 L2_N9 1.0300208615e+05
R_Dense_2_167_9 L1_N167 L2_N9 4.6180831754e+05
R_Dense_2_168_9 L1_N168 L2_N9 1.5736311001e+05
R_Dense_2_169_9 L1_N169 L2_N9 1.5198936338e+06
R_Dense_2_170_9 L1_N170 L2_N9 4.3082169026e+06
R_Dense_2_171_9 L1_N171 L2_N9 6.0982663305e+05
R_Dense_2_172_9 L1_N172 L2_N9 1.5695168367e+05
R_Dense_2_173_9 L1_N173 L2_N9 2.1222272278e+05
R_Dense_2_174_9 L1_N174 L2_N9 1.5449274557e+06
R_Dense_2_175_9 L1_N175 L2_N9 2.3210427374e+05
R_Dense_2_176_9 L1_N176 L2_N9 1.0016599010e+05
R_Dense_2_177_9 L1_N177 L2_N9 1.1150628067e+06
R_Dense_2_178_9 L1_N178 L2_N9 2.2388154608e+05
R_Dense_2_179_9 L1_N179 L2_N9 1.2879034569e+06
R_Dense_2_180_9 L1_N180 L2_N9 1.7301354284e+06
R_Dense_2_181_9 L1_N181 L2_N9 2.0198510252e+05
R_Dense_2_182_9 L1_N182 L2_N9 2.7066598248e+05
R_Dense_2_183_9 L1_N183 L2_N9 3.5529674457e+06
R_Dense_2_184_9 L1_N184 L2_N9 1.1049270753e+05
R_Dense_2_185_9 L1_N185 L2_N9 1.5493650719e+05
R_Dense_2_186_9 L1_N186 L2_N9 6.7482613567e+05
R_Dense_2_187_9 L1_N187 L2_N9 6.5947195965e+05
R_Dense_2_188_9 L1_N188 L2_N9 1.5389810885e+05
R_Dense_2_189_9 L1_N189 L2_N9 1.4808301661e+05
R_Dense_2_190_9 L1_N190 L2_N9 1.1001198458e+05
R_Dense_2_191_9 L1_N191 L2_N9 1.0434940623e+05
R_Dense_2_192_9 L1_N192 L2_N9 1.6512712259e+05
R_Dense_2_193_9 L1_N193 L2_N9 6.4111839805e+05
R_Dense_2_194_9 L1_N194 L2_N9 1.0132263507e+05
R_Dense_2_195_9 L1_N195 L2_N9 1.7025358768e+05
R_Dense_2_196_9 L1_N196 L2_N9 1.5520767916e+06
R_Dense_2_197_9 L1_N197 L2_N9 1.0313626393e+05
R_Dense_2_198_9 L1_N198 L2_N9 1.0030885288e+05
R_Dense_2_199_9 L1_N199 L2_N9 1.1024461025e+06
R_Dense_2_200_9 L1_N200 L2_N9 4.1705272848e+05
R_Dense_2_201_9 L1_N201 L2_N9 4.7488518131e+05
R_Dense_2_202_9 L1_N202 L2_N9 1.5603106659e+05
R_Dense_2_203_9 L1_N203 L2_N9 2.4031043395e+05
R_Dense_2_204_9 L1_N204 L2_N9 1.1235603448e+05
R_Dense_2_205_9 L1_N205 L2_N9 1.0011793557e+06
R_Dense_2_206_9 L1_N206 L2_N9 4.6380401159e+05
R_Dense_2_207_9 L1_N207 L2_N9 1.2324657022e+05
R_Dense_2_208_9 L1_N208 L2_N9 5.5684805745e+05
R_Dense_2_209_9 L1_N209 L2_N9 1.5011335384e+05
R_Dense_2_210_9 L1_N210 L2_N9 2.5654765551e+05
R_Dense_2_211_9 L1_N211 L2_N9 1.1068053857e+05
R_Dense_2_212_9 L1_N212 L2_N9 2.0776250671e+05
R_Dense_2_213_9 L1_N213 L2_N9 4.5926608742e+05
R_Dense_2_214_9 L1_N214 L2_N9 1.5638279012e+05
R_Dense_2_215_9 L1_N215 L2_N9 1.7569036150e+05
R_Dense_2_216_9 L1_N216 L2_N9 1.6221283019e+05
R_Dense_2_217_9 L1_N217 L2_N9 1.1373640892e+05
R_Dense_2_218_9 L1_N218 L2_N9 6.9577207400e+05
R_Dense_2_219_9 L1_N219 L2_N9 5.7738185315e+05
R_Dense_2_220_9 L1_N220 L2_N9 1.7537954459e+05
R_Dense_2_221_9 L1_N221 L2_N9 1.1243753575e+05
R_Dense_2_222_9 L1_N222 L2_N9 3.1446918296e+05
R_Dense_2_223_9 L1_N223 L2_N9 2.0418179307e+05
R_Dense_2_224_9 L1_N224 L2_N9 1.1369287945e+05
R_Dense_2_225_9 L1_N225 L2_N9 1.2977169469e+05
R_Dense_2_226_9 L1_N226 L2_N9 6.2439584794e+05
R_Dense_2_227_9 L1_N227 L2_N9 3.1515272471e+05
R_Dense_2_228_9 L1_N228 L2_N9 1.0528165669e+05
R_Dense_2_229_9 L1_N229 L2_N9 3.0058356035e+05
R_Dense_2_230_9 L1_N230 L2_N9 7.1574175184e+05
R_Dense_2_231_9 L1_N231 L2_N9 5.4551418054e+05
R_Dense_2_232_9 L1_N232 L2_N9 3.5915782038e+05
R_Dense_2_233_9 L1_N233 L2_N9 2.0345105265e+05
R_Dense_2_234_9 L1_N234 L2_N9 1.2802018824e+05
R_Dense_2_235_9 L1_N235 L2_N9 8.1628708618e+05
R_Dense_2_236_9 L1_N236 L2_N9 1.0865394696e+05
R_Dense_2_237_9 L1_N237 L2_N9 2.0611230620e+05
R_Dense_2_238_9 L1_N238 L2_N9 1.7615514814e+05
R_Dense_2_239_9 L1_N239 L2_N9 3.3929709153e+05
R_Dense_2_240_9 L1_N240 L2_N9 1.2255622961e+05
R_Dense_2_241_9 L1_N241 L2_N9 1.3383177482e+05
R_Dense_2_242_9 L1_N242 L2_N9 1.4665407136e+05
R_Dense_2_243_9 L1_N243 L2_N9 1.8754210638e+05
R_Dense_2_244_9 L1_N244 L2_N9 2.9289158746e+05
R_Dense_2_245_9 L1_N245 L2_N9 1.7350024986e+05
R_Dense_2_246_9 L1_N246 L2_N9 2.3284158752e+06
R_Dense_2_247_9 L1_N247 L2_N9 1.2726446265e+05
R_Dense_2_248_9 L1_N248 L2_N9 2.0936876282e+05
R_Dense_2_249_9 L1_N249 L2_N9 5.8771455564e+05
R_Dense_2_250_9 L1_N250 L2_N9 2.3568662910e+05
R_Dense_2_251_9 L1_N251 L2_N9 6.4297092024e+05
R_Dense_2_252_9 L1_N252 L2_N9 3.5384283161e+05
R_Dense_2_253_9 L1_N253 L2_N9 2.5524338925e+05
R_Dense_2_254_9 L1_N254 L2_N9 1.9956294727e+05
R_Dense_2_255_9 L1_N255 L2_N9 1.9690962056e+05
R_Dense_2_256_9 L1_N256 L2_N9 2.5626658968e+05
R_Dense_2_257_9 L1_N257 L2_N9 1.0713221248e+06
R_Dense_2_258_9 L1_N258 L2_N9 7.0616963046e+05
R_Dense_2_259_9 L1_N259 L2_N9 2.6588317189e+05
R_Dense_2_260_9 L1_N260 L2_N9 2.1930156607e+05
R_Dense_2_261_9 L1_N261 L2_N9 2.9779253521e+05
R_Dense_2_262_9 L1_N262 L2_N9 8.3056945812e+05
R_Dense_2_263_9 L1_N263 L2_N9 1.1379528036e+05
R_Dense_2_264_9 L1_N264 L2_N9 1.6105782600e+05
R_Dense_2_265_9 L1_N265 L2_N9 1.5660533256e+05
R_Dense_2_266_9 L1_N266 L2_N9 5.2933527031e+05
R_Dense_2_267_9 L1_N267 L2_N9 9.1742182647e+05
R_Dense_2_268_9 L1_N268 L2_N9 3.4108377619e+05
R_Dense_2_269_9 L1_N269 L2_N9 3.1936914810e+05
R_Dense_2_270_9 L1_N270 L2_N9 1.0003746886e+05
R_Dense_2_271_9 L1_N271 L2_N9 7.2989032614e+05
R_Dense_2_272_9 L1_N272 L2_N9 2.0021469479e+05
R_Dense_2_273_9 L1_N273 L2_N9 1.2254244184e+05
R_Dense_2_274_9 L1_N274 L2_N9 4.6964421708e+05
R_Dense_2_275_9 L1_N275 L2_N9 1.7386839516e+05
R_Dense_2_276_9 L1_N276 L2_N9 3.7940441220e+05
R_Dense_2_277_9 L1_N277 L2_N9 1.7902802521e+05
R_Dense_2_278_9 L1_N278 L2_N9 2.4102144460e+05
R_Dense_2_279_9 L1_N279 L2_N9 1.0297843882e+05
R_Dense_2_280_9 L1_N280 L2_N9 1.1384274169e+05
R_Dense_2_281_9 L1_N281 L2_N9 3.3313772808e+05
R_Dense_2_282_9 L1_N282 L2_N9 2.9921501637e+06
R_Dense_2_283_9 L1_N283 L2_N9 1.7074070965e+05
R_Dense_2_284_9 L1_N284 L2_N9 7.9957362345e+05
R_Dense_2_285_9 L1_N285 L2_N9 1.2821718937e+05
R_Dense_2_286_9 L1_N286 L2_N9 2.9306876200e+05
R_Dense_2_287_9 L1_N287 L2_N9 2.1729031441e+05
R_Dense_2_288_9 L1_N288 L2_N9 1.4079057233e+05
R_Dense_2_289_9 L1_N289 L2_N9 1.2994512124e+05
R_Dense_2_290_9 L1_N290 L2_N9 3.2711664250e+05
R_Dense_2_291_9 L1_N291 L2_N9 1.5561407034e+05
R_Dense_2_292_9 L1_N292 L2_N9 1.4889982033e+05
R_Dense_2_293_9 L1_N293 L2_N9 4.2872452807e+05
R_Dense_2_294_9 L1_N294 L2_N9 4.9848854105e+05
R_Dense_2_295_9 L1_N295 L2_N9 1.1330643679e+05
R_Dense_2_296_9 L1_N296 L2_N9 1.3149355107e+05
R_Dense_2_297_9 L1_N297 L2_N9 3.2524956786e+05
R_Dense_2_298_9 L1_N298 L2_N9 2.6584988266e+05
R_Dense_2_299_9 L1_N299 L2_N9 1.8725336240e+05
R_Dense_2_300_9 L1_N300 L2_N9 5.7629116139e+06
R_Dense_2_301_9 L1_N301 L2_N9 1.6986427363e+05
R_Dense_2_302_9 L1_N302 L2_N9 9.2204137257e+05
R_Dense_2_303_9 L1_N303 L2_N9 2.6427700850e+05
R_Dense_2_304_9 L1_N304 L2_N9 2.6976638623e+05
R_Dense_2_305_9 L1_N305 L2_N9 1.8925724982e+05
R_Dense_2_306_9 L1_N306 L2_N9 1.3901056429e+05
R_Dense_2_307_9 L1_N307 L2_N9 1.2525001546e+05
R_Dense_2_308_9 L1_N308 L2_N9 7.4793908854e+05
R_Dense_2_309_9 L1_N309 L2_N9 5.2181494972e+05
R_Dense_2_310_9 L1_N310 L2_N9 2.3168446740e+05
R_Dense_2_311_9 L1_N311 L2_N9 1.2319713408e+05
R_Dense_2_312_9 L1_N312 L2_N9 2.5941408817e+06
R_Dense_2_313_9 L1_N313 L2_N9 1.0890812357e+05
R_Dense_2_314_9 L1_N314 L2_N9 5.6659589795e+05
R_Dense_2_315_9 L1_N315 L2_N9 3.9112437459e+05
R_Dense_2_316_9 L1_N316 L2_N9 1.2717704083e+06
R_Dense_2_317_9 L1_N317 L2_N9 2.2783827497e+05
R_Dense_2_318_9 L1_N318 L2_N9 5.3361486955e+06
R_Dense_2_319_9 L1_N319 L2_N9 1.4551537276e+05
R_Dense_2_320_9 L1_N320 L2_N9 1.9479736848e+05
R_Dense_2_321_9 L1_N321 L2_N9 2.5035168016e+05
R_Dense_2_322_9 L1_N322 L2_N9 2.2236820257e+05
R_Dense_2_323_9 L1_N323 L2_N9 1.5421336317e+05
R_Dense_2_324_9 L1_N324 L2_N9 1.1444766341e+05
R_Dense_2_325_9 L1_N325 L2_N9 6.3129793220e+05
R_Dense_2_326_9 L1_N326 L2_N9 4.6838263970e+05
R_Dense_2_327_9 L1_N327 L2_N9 2.7507251289e+05
R_Dense_2_328_9 L1_N328 L2_N9 2.9374291550e+05
R_Dense_2_329_9 L1_N329 L2_N9 7.9543891754e+05
R_Dense_2_330_9 L1_N330 L2_N9 1.9093492621e+05
R_Dense_2_331_9 L1_N331 L2_N9 1.0230357913e+05
R_Dense_2_332_9 L1_N332 L2_N9 1.2590133093e+05
R_Dense_2_333_9 L1_N333 L2_N9 2.3987170270e+05
R_Dense_2_334_9 L1_N334 L2_N9 3.3099342855e+05
R_Dense_2_335_9 L1_N335 L2_N9 1.0780583593e+05
R_Dense_2_336_9 L1_N336 L2_N9 2.9100428289e+05
R_Dense_2_337_9 L1_N337 L2_N9 1.5532534938e+05
*
R_Dense_2_0_10 L1_N0 L2_N10 8.8287466630e+05
R_Dense_2_1_10 L1_N1 L2_N10 2.5812447538e+05
R_Dense_2_2_10 L1_N2 L2_N10 1.7407097464e+05
R_Dense_2_3_10 L1_N3 L2_N10 1.3553492907e+05
R_Dense_2_4_10 L1_N4 L2_N10 1.2740630651e+05
R_Dense_2_5_10 L1_N5 L2_N10 1.8425292802e+05
R_Dense_2_6_10 L1_N6 L2_N10 1.4194377075e+06
R_Dense_2_7_10 L1_N7 L2_N10 5.0581972333e+05
R_Dense_2_8_10 L1_N8 L2_N10 1.4276757457e+05
R_Dense_2_9_10 L1_N9 L2_N10 1.1918521444e+06
R_Dense_2_10_10 L1_N10 L2_N10 1.0372226655e+05
R_Dense_2_11_10 L1_N11 L2_N10 2.2413290761e+05
R_Dense_2_12_10 L1_N12 L2_N10 1.0214870725e+05
R_Dense_2_13_10 L1_N13 L2_N10 1.8883414145e+05
R_Dense_2_14_10 L1_N14 L2_N10 1.2342841046e+05
R_Dense_2_15_10 L1_N15 L2_N10 4.3200793526e+05
R_Dense_2_16_10 L1_N16 L2_N10 3.1221037619e+05
R_Dense_2_17_10 L1_N17 L2_N10 1.1181889382e+05
R_Dense_2_18_10 L1_N18 L2_N10 1.3722237380e+05
R_Dense_2_19_10 L1_N19 L2_N10 3.5512186638e+06
R_Dense_2_20_10 L1_N20 L2_N10 6.5773335898e+05
R_Dense_2_21_10 L1_N21 L2_N10 1.9731789614e+05
R_Dense_2_22_10 L1_N22 L2_N10 1.0227568422e+06
R_Dense_2_23_10 L1_N23 L2_N10 4.9822422930e+05
R_Dense_2_24_10 L1_N24 L2_N10 1.1801443968e+05
R_Dense_2_25_10 L1_N25 L2_N10 2.4531436881e+05
R_Dense_2_26_10 L1_N26 L2_N10 1.9634459179e+05
R_Dense_2_27_10 L1_N27 L2_N10 1.2522089790e+05
R_Dense_2_28_10 L1_N28 L2_N10 1.0678547892e+05
R_Dense_2_29_10 L1_N29 L2_N10 1.6479011737e+05
R_Dense_2_30_10 L1_N30 L2_N10 1.2891787068e+05
R_Dense_2_31_10 L1_N31 L2_N10 2.3661014689e+05
R_Dense_2_32_10 L1_N32 L2_N10 4.7340425602e+05
R_Dense_2_33_10 L1_N33 L2_N10 3.4358630951e+05
R_Dense_2_34_10 L1_N34 L2_N10 3.8748817154e+05
R_Dense_2_35_10 L1_N35 L2_N10 2.1641171434e+05
R_Dense_2_36_10 L1_N36 L2_N10 4.9721803924e+05
R_Dense_2_37_10 L1_N37 L2_N10 1.3258777149e+05
R_Dense_2_38_10 L1_N38 L2_N10 3.5636911681e+05
R_Dense_2_39_10 L1_N39 L2_N10 3.9285851387e+05
R_Dense_2_40_10 L1_N40 L2_N10 1.0111655398e+06
R_Dense_2_41_10 L1_N41 L2_N10 1.4582653206e+05
R_Dense_2_42_10 L1_N42 L2_N10 1.3791267000e+05
R_Dense_2_43_10 L1_N43 L2_N10 1.2155920639e+05
R_Dense_2_44_10 L1_N44 L2_N10 3.1454881376e+06
R_Dense_2_45_10 L1_N45 L2_N10 1.3453600425e+05
R_Dense_2_46_10 L1_N46 L2_N10 4.5799347023e+05
R_Dense_2_47_10 L1_N47 L2_N10 1.4347608901e+05
R_Dense_2_48_10 L1_N48 L2_N10 3.0938318514e+05
R_Dense_2_49_10 L1_N49 L2_N10 1.5150084872e+05
R_Dense_2_50_10 L1_N50 L2_N10 1.2648741146e+05
R_Dense_2_51_10 L1_N51 L2_N10 2.3574376369e+05
R_Dense_2_52_10 L1_N52 L2_N10 1.9028577529e+05
R_Dense_2_53_10 L1_N53 L2_N10 1.1949687054e+05
R_Dense_2_54_10 L1_N54 L2_N10 2.2769919855e+05
R_Dense_2_55_10 L1_N55 L2_N10 1.4332350028e+05
R_Dense_2_56_10 L1_N56 L2_N10 3.0310505753e+05
R_Dense_2_57_10 L1_N57 L2_N10 1.4736496231e+05
R_Dense_2_58_10 L1_N58 L2_N10 1.3185782659e+05
R_Dense_2_59_10 L1_N59 L2_N10 1.2088464622e+05
R_Dense_2_60_10 L1_N60 L2_N10 1.0683474850e+05
R_Dense_2_61_10 L1_N61 L2_N10 4.4698219854e+05
R_Dense_2_62_10 L1_N62 L2_N10 8.7317520720e+05
R_Dense_2_63_10 L1_N63 L2_N10 1.0460847895e+05
R_Dense_2_64_10 L1_N64 L2_N10 2.0466011330e+05
R_Dense_2_65_10 L1_N65 L2_N10 1.4234590275e+05
R_Dense_2_66_10 L1_N66 L2_N10 1.0242280377e+05
R_Dense_2_67_10 L1_N67 L2_N10 1.2198182374e+05
R_Dense_2_68_10 L1_N68 L2_N10 1.6694683513e+05
R_Dense_2_69_10 L1_N69 L2_N10 1.2162577744e+05
R_Dense_2_70_10 L1_N70 L2_N10 1.3439143003e+05
R_Dense_2_71_10 L1_N71 L2_N10 7.0765049259e+06
R_Dense_2_72_10 L1_N72 L2_N10 1.4391167251e+05
R_Dense_2_73_10 L1_N73 L2_N10 1.4695681097e+05
R_Dense_2_74_10 L1_N74 L2_N10 2.7242194109e+06
R_Dense_2_75_10 L1_N75 L2_N10 2.3889305838e+06
R_Dense_2_76_10 L1_N76 L2_N10 3.2912852877e+05
R_Dense_2_77_10 L1_N77 L2_N10 3.6559805600e+05
R_Dense_2_78_10 L1_N78 L2_N10 1.0061155491e+05
R_Dense_2_79_10 L1_N79 L2_N10 3.5505074284e+05
R_Dense_2_80_10 L1_N80 L2_N10 1.0820942680e+05
R_Dense_2_81_10 L1_N81 L2_N10 1.2240903775e+05
R_Dense_2_82_10 L1_N82 L2_N10 1.0790796675e+05
R_Dense_2_83_10 L1_N83 L2_N10 2.2521108417e+05
R_Dense_2_84_10 L1_N84 L2_N10 1.5372820811e+06
R_Dense_2_85_10 L1_N85 L2_N10 1.0028888391e+05
R_Dense_2_86_10 L1_N86 L2_N10 1.3562989291e+05
R_Dense_2_87_10 L1_N87 L2_N10 1.5617591101e+05
R_Dense_2_88_10 L1_N88 L2_N10 8.6042214232e+06
R_Dense_2_89_10 L1_N89 L2_N10 4.9853953259e+05
R_Dense_2_90_10 L1_N90 L2_N10 2.4592879387e+05
R_Dense_2_91_10 L1_N91 L2_N10 2.0405865958e+05
R_Dense_2_92_10 L1_N92 L2_N10 2.8717315302e+05
R_Dense_2_93_10 L1_N93 L2_N10 3.2330151222e+05
R_Dense_2_94_10 L1_N94 L2_N10 1.8518342611e+05
R_Dense_2_95_10 L1_N95 L2_N10 1.6977048158e+05
R_Dense_2_96_10 L1_N96 L2_N10 1.7337422377e+05
R_Dense_2_97_10 L1_N97 L2_N10 1.0246409532e+05
R_Dense_2_98_10 L1_N98 L2_N10 4.7545814550e+06
R_Dense_2_99_10 L1_N99 L2_N10 1.7025402248e+06
R_Dense_2_100_10 L1_N100 L2_N10 5.4678811424e+05
R_Dense_2_101_10 L1_N101 L2_N10 1.0584935496e+05
R_Dense_2_102_10 L1_N102 L2_N10 5.2212639490e+05
R_Dense_2_103_10 L1_N103 L2_N10 1.1758773286e+05
R_Dense_2_104_10 L1_N104 L2_N10 1.1699005072e+05
R_Dense_2_105_10 L1_N105 L2_N10 2.2828312690e+05
R_Dense_2_106_10 L1_N106 L2_N10 1.2795195945e+05
R_Dense_2_107_10 L1_N107 L2_N10 2.7025081240e+05
R_Dense_2_108_10 L1_N108 L2_N10 1.9911341958e+06
R_Dense_2_109_10 L1_N109 L2_N10 1.0770851726e+05
R_Dense_2_110_10 L1_N110 L2_N10 1.3961297830e+05
R_Dense_2_111_10 L1_N111 L2_N10 1.1120732803e+05
R_Dense_2_112_10 L1_N112 L2_N10 3.3988640400e+05
R_Dense_2_113_10 L1_N113 L2_N10 1.0148756576e+05
R_Dense_2_114_10 L1_N114 L2_N10 1.0706206420e+05
R_Dense_2_115_10 L1_N115 L2_N10 2.0108569997e+05
R_Dense_2_116_10 L1_N116 L2_N10 2.0394102952e+05
R_Dense_2_117_10 L1_N117 L2_N10 1.1033227026e+05
R_Dense_2_118_10 L1_N118 L2_N10 2.7134067269e+05
R_Dense_2_119_10 L1_N119 L2_N10 1.2802493486e+05
R_Dense_2_120_10 L1_N120 L2_N10 1.6159676290e+05
R_Dense_2_121_10 L1_N121 L2_N10 1.7757366372e+05
R_Dense_2_122_10 L1_N122 L2_N10 1.0142325955e+05
R_Dense_2_123_10 L1_N123 L2_N10 1.4444125784e+05
R_Dense_2_124_10 L1_N124 L2_N10 1.8469302939e+05
R_Dense_2_125_10 L1_N125 L2_N10 3.2386295982e+05
R_Dense_2_126_10 L1_N126 L2_N10 2.6056519159e+05
R_Dense_2_127_10 L1_N127 L2_N10 2.1227696221e+05
R_Dense_2_128_10 L1_N128 L2_N10 1.7719736433e+05
R_Dense_2_129_10 L1_N129 L2_N10 1.0878111786e+06
R_Dense_2_130_10 L1_N130 L2_N10 1.1669586073e+05
R_Dense_2_131_10 L1_N131 L2_N10 1.1495440635e+05
R_Dense_2_132_10 L1_N132 L2_N10 1.6836173458e+05
R_Dense_2_133_10 L1_N133 L2_N10 3.0321802807e+05
R_Dense_2_134_10 L1_N134 L2_N10 1.0105326916e+05
R_Dense_2_135_10 L1_N135 L2_N10 1.7616580545e+05
R_Dense_2_136_10 L1_N136 L2_N10 1.4766990025e+05
R_Dense_2_137_10 L1_N137 L2_N10 1.1028390715e+06
R_Dense_2_138_10 L1_N138 L2_N10 3.2109115621e+05
R_Dense_2_139_10 L1_N139 L2_N10 1.4128057083e+05
R_Dense_2_140_10 L1_N140 L2_N10 2.1913115101e+05
R_Dense_2_141_10 L1_N141 L2_N10 1.3832233735e+05
R_Dense_2_142_10 L1_N142 L2_N10 2.3109477108e+05
R_Dense_2_143_10 L1_N143 L2_N10 1.7305502660e+05
R_Dense_2_144_10 L1_N144 L2_N10 1.0978249302e+05
R_Dense_2_145_10 L1_N145 L2_N10 1.0694432357e+05
R_Dense_2_146_10 L1_N146 L2_N10 1.0673203747e+05
R_Dense_2_147_10 L1_N147 L2_N10 1.2725771867e+05
R_Dense_2_148_10 L1_N148 L2_N10 8.4495625553e+05
R_Dense_2_149_10 L1_N149 L2_N10 1.4352462454e+05
R_Dense_2_150_10 L1_N150 L2_N10 4.5012512570e+05
R_Dense_2_151_10 L1_N151 L2_N10 8.9596572769e+05
R_Dense_2_152_10 L1_N152 L2_N10 1.3709809436e+05
R_Dense_2_153_10 L1_N153 L2_N10 1.4894980115e+05
R_Dense_2_154_10 L1_N154 L2_N10 1.1811290563e+05
R_Dense_2_155_10 L1_N155 L2_N10 2.9374312766e+05
R_Dense_2_156_10 L1_N156 L2_N10 1.8730383716e+05
R_Dense_2_157_10 L1_N157 L2_N10 2.6541401898e+05
R_Dense_2_158_10 L1_N158 L2_N10 1.2911636250e+06
R_Dense_2_159_10 L1_N159 L2_N10 1.3407102799e+05
R_Dense_2_160_10 L1_N160 L2_N10 1.6360098891e+05
R_Dense_2_161_10 L1_N161 L2_N10 3.6232859472e+05
R_Dense_2_162_10 L1_N162 L2_N10 3.2941292674e+05
R_Dense_2_163_10 L1_N163 L2_N10 6.2928254397e+05
R_Dense_2_164_10 L1_N164 L2_N10 2.1821002139e+05
R_Dense_2_165_10 L1_N165 L2_N10 1.6261389545e+05
R_Dense_2_166_10 L1_N166 L2_N10 1.1299612626e+05
R_Dense_2_167_10 L1_N167 L2_N10 4.2387674307e+05
R_Dense_2_168_10 L1_N168 L2_N10 2.9040022791e+05
R_Dense_2_169_10 L1_N169 L2_N10 1.1444874358e+05
R_Dense_2_170_10 L1_N170 L2_N10 1.4242847126e+05
R_Dense_2_171_10 L1_N171 L2_N10 1.1153436598e+05
R_Dense_2_172_10 L1_N172 L2_N10 1.0689985126e+05
R_Dense_2_173_10 L1_N173 L2_N10 1.6266638746e+06
R_Dense_2_174_10 L1_N174 L2_N10 3.1468901250e+05
R_Dense_2_175_10 L1_N175 L2_N10 1.0185403909e+06
R_Dense_2_176_10 L1_N176 L2_N10 1.1988538391e+05
R_Dense_2_177_10 L1_N177 L2_N10 4.2197264655e+05
R_Dense_2_178_10 L1_N178 L2_N10 6.8328882827e+05
R_Dense_2_179_10 L1_N179 L2_N10 3.9252275643e+05
R_Dense_2_180_10 L1_N180 L2_N10 6.9550087609e+05
R_Dense_2_181_10 L1_N181 L2_N10 1.1339438532e+05
R_Dense_2_182_10 L1_N182 L2_N10 1.4054652161e+06
R_Dense_2_183_10 L1_N183 L2_N10 8.3612728167e+05
R_Dense_2_184_10 L1_N184 L2_N10 1.9961087986e+05
R_Dense_2_185_10 L1_N185 L2_N10 1.6045497260e+05
R_Dense_2_186_10 L1_N186 L2_N10 1.5737596009e+05
R_Dense_2_187_10 L1_N187 L2_N10 4.1418881489e+05
R_Dense_2_188_10 L1_N188 L2_N10 2.4941117446e+05
R_Dense_2_189_10 L1_N189 L2_N10 4.6910820162e+05
R_Dense_2_190_10 L1_N190 L2_N10 1.0209466866e+05
R_Dense_2_191_10 L1_N191 L2_N10 1.2603730794e+05
R_Dense_2_192_10 L1_N192 L2_N10 1.1109251867e+05
R_Dense_2_193_10 L1_N193 L2_N10 1.6405259417e+06
R_Dense_2_194_10 L1_N194 L2_N10 1.0938883940e+05
R_Dense_2_195_10 L1_N195 L2_N10 1.8462693497e+05
R_Dense_2_196_10 L1_N196 L2_N10 9.2893403402e+05
R_Dense_2_197_10 L1_N197 L2_N10 2.4151642727e+05
R_Dense_2_198_10 L1_N198 L2_N10 1.3280016800e+05
R_Dense_2_199_10 L1_N199 L2_N10 2.3416087331e+05
R_Dense_2_200_10 L1_N200 L2_N10 6.3077613385e+05
R_Dense_2_201_10 L1_N201 L2_N10 4.1999830148e+05
R_Dense_2_202_10 L1_N202 L2_N10 1.4369668435e+05
R_Dense_2_203_10 L1_N203 L2_N10 2.1782892941e+05
R_Dense_2_204_10 L1_N204 L2_N10 1.2339098634e+06
R_Dense_2_205_10 L1_N205 L2_N10 3.7382580958e+05
R_Dense_2_206_10 L1_N206 L2_N10 1.9648916121e+05
R_Dense_2_207_10 L1_N207 L2_N10 1.2785666423e+05
R_Dense_2_208_10 L1_N208 L2_N10 1.2037630443e+05
R_Dense_2_209_10 L1_N209 L2_N10 4.6037524765e+05
R_Dense_2_210_10 L1_N210 L2_N10 8.2814394756e+05
R_Dense_2_211_10 L1_N211 L2_N10 1.8446725412e+05
R_Dense_2_212_10 L1_N212 L2_N10 1.2458328780e+05
R_Dense_2_213_10 L1_N213 L2_N10 1.2906028419e+05
R_Dense_2_214_10 L1_N214 L2_N10 1.0212509246e+05
R_Dense_2_215_10 L1_N215 L2_N10 3.0752708024e+05
R_Dense_2_216_10 L1_N216 L2_N10 1.1993954382e+05
R_Dense_2_217_10 L1_N217 L2_N10 3.6069249018e+05
R_Dense_2_218_10 L1_N218 L2_N10 6.6445588300e+05
R_Dense_2_219_10 L1_N219 L2_N10 2.5350667494e+05
R_Dense_2_220_10 L1_N220 L2_N10 3.8398747650e+05
R_Dense_2_221_10 L1_N221 L2_N10 1.6840038097e+05
R_Dense_2_222_10 L1_N222 L2_N10 1.4041133266e+05
R_Dense_2_223_10 L1_N223 L2_N10 3.4894492525e+05
R_Dense_2_224_10 L1_N224 L2_N10 1.3953795520e+05
R_Dense_2_225_10 L1_N225 L2_N10 8.0338532408e+05
R_Dense_2_226_10 L1_N226 L2_N10 2.9849040298e+05
R_Dense_2_227_10 L1_N227 L2_N10 5.3679989319e+05
R_Dense_2_228_10 L1_N228 L2_N10 1.0828697190e+05
R_Dense_2_229_10 L1_N229 L2_N10 1.1097082633e+05
R_Dense_2_230_10 L1_N230 L2_N10 1.3106061247e+05
R_Dense_2_231_10 L1_N231 L2_N10 1.7772801499e+05
R_Dense_2_232_10 L1_N232 L2_N10 2.1841365729e+05
R_Dense_2_233_10 L1_N233 L2_N10 2.1273250283e+05
R_Dense_2_234_10 L1_N234 L2_N10 1.0693145632e+05
R_Dense_2_235_10 L1_N235 L2_N10 1.6365062980e+05
R_Dense_2_236_10 L1_N236 L2_N10 2.6409942653e+05
R_Dense_2_237_10 L1_N237 L2_N10 1.5389623865e+05
R_Dense_2_238_10 L1_N238 L2_N10 3.8493197945e+05
R_Dense_2_239_10 L1_N239 L2_N10 2.3816528287e+05
R_Dense_2_240_10 L1_N240 L2_N10 1.1333462479e+05
R_Dense_2_241_10 L1_N241 L2_N10 3.0237887668e+05
R_Dense_2_242_10 L1_N242 L2_N10 5.6775570524e+05
R_Dense_2_243_10 L1_N243 L2_N10 1.3084453942e+05
R_Dense_2_244_10 L1_N244 L2_N10 7.7884349723e+05
R_Dense_2_245_10 L1_N245 L2_N10 1.7601984072e+05
R_Dense_2_246_10 L1_N246 L2_N10 9.6897472687e+05
R_Dense_2_247_10 L1_N247 L2_N10 1.9793460117e+05
R_Dense_2_248_10 L1_N248 L2_N10 2.3282592950e+05
R_Dense_2_249_10 L1_N249 L2_N10 1.2148996468e+05
R_Dense_2_250_10 L1_N250 L2_N10 1.0685870789e+05
R_Dense_2_251_10 L1_N251 L2_N10 4.0907807763e+06
R_Dense_2_252_10 L1_N252 L2_N10 1.4491076697e+05
R_Dense_2_253_10 L1_N253 L2_N10 2.1346378101e+05
R_Dense_2_254_10 L1_N254 L2_N10 4.9404615630e+05
R_Dense_2_255_10 L1_N255 L2_N10 3.0684818464e+05
R_Dense_2_256_10 L1_N256 L2_N10 1.2420527952e+05
R_Dense_2_257_10 L1_N257 L2_N10 1.5824516618e+05
R_Dense_2_258_10 L1_N258 L2_N10 1.2800967103e+05
R_Dense_2_259_10 L1_N259 L2_N10 1.7185883661e+05
R_Dense_2_260_10 L1_N260 L2_N10 1.1159197082e+05
R_Dense_2_261_10 L1_N261 L2_N10 1.7017786653e+05
R_Dense_2_262_10 L1_N262 L2_N10 1.4546044073e+05
R_Dense_2_263_10 L1_N263 L2_N10 2.9647916946e+05
R_Dense_2_264_10 L1_N264 L2_N10 1.9678782953e+06
R_Dense_2_265_10 L1_N265 L2_N10 3.2423876688e+06
R_Dense_2_266_10 L1_N266 L2_N10 1.1206651007e+05
R_Dense_2_267_10 L1_N267 L2_N10 2.3161763919e+05
R_Dense_2_268_10 L1_N268 L2_N10 3.7421501003e+05
R_Dense_2_269_10 L1_N269 L2_N10 3.0046719600e+05
R_Dense_2_270_10 L1_N270 L2_N10 1.0600834250e+05
R_Dense_2_271_10 L1_N271 L2_N10 1.0855056987e+05
R_Dense_2_272_10 L1_N272 L2_N10 1.1201067396e+05
R_Dense_2_273_10 L1_N273 L2_N10 1.2649925045e+05
R_Dense_2_274_10 L1_N274 L2_N10 1.1745124896e+05
R_Dense_2_275_10 L1_N275 L2_N10 1.3191131711e+05
R_Dense_2_276_10 L1_N276 L2_N10 2.5725652641e+06
R_Dense_2_277_10 L1_N277 L2_N10 4.6662388529e+05
R_Dense_2_278_10 L1_N278 L2_N10 3.9729786167e+05
R_Dense_2_279_10 L1_N279 L2_N10 1.5866474247e+05
R_Dense_2_280_10 L1_N280 L2_N10 1.3434202633e+05
R_Dense_2_281_10 L1_N281 L2_N10 1.3605534248e+05
R_Dense_2_282_10 L1_N282 L2_N10 2.1444351146e+05
R_Dense_2_283_10 L1_N283 L2_N10 4.3308793426e+05
R_Dense_2_284_10 L1_N284 L2_N10 1.5959118334e+06
R_Dense_2_285_10 L1_N285 L2_N10 1.6660591010e+05
R_Dense_2_286_10 L1_N286 L2_N10 1.3513827628e+05
R_Dense_2_287_10 L1_N287 L2_N10 6.7143730468e+05
R_Dense_2_288_10 L1_N288 L2_N10 1.1879955456e+05
R_Dense_2_289_10 L1_N289 L2_N10 2.5400250465e+05
R_Dense_2_290_10 L1_N290 L2_N10 1.1878996920e+06
R_Dense_2_291_10 L1_N291 L2_N10 1.0823393228e+05
R_Dense_2_292_10 L1_N292 L2_N10 1.1966394810e+05
R_Dense_2_293_10 L1_N293 L2_N10 2.9063060425e+05
R_Dense_2_294_10 L1_N294 L2_N10 3.2352093431e+05
R_Dense_2_295_10 L1_N295 L2_N10 1.5692784937e+05
R_Dense_2_296_10 L1_N296 L2_N10 7.0823936388e+05
R_Dense_2_297_10 L1_N297 L2_N10 3.5981530380e+06
R_Dense_2_298_10 L1_N298 L2_N10 1.0228438584e+05
R_Dense_2_299_10 L1_N299 L2_N10 2.6827451780e+05
R_Dense_2_300_10 L1_N300 L2_N10 1.7825962082e+05
R_Dense_2_301_10 L1_N301 L2_N10 1.0822350894e+05
R_Dense_2_302_10 L1_N302 L2_N10 6.9366352325e+05
R_Dense_2_303_10 L1_N303 L2_N10 2.8787971466e+05
R_Dense_2_304_10 L1_N304 L2_N10 1.0247404993e+05
R_Dense_2_305_10 L1_N305 L2_N10 1.2799688824e+05
R_Dense_2_306_10 L1_N306 L2_N10 7.4409321262e+05
R_Dense_2_307_10 L1_N307 L2_N10 1.4738826412e+05
R_Dense_2_308_10 L1_N308 L2_N10 1.5527934779e+05
R_Dense_2_309_10 L1_N309 L2_N10 1.2236217076e+05
R_Dense_2_310_10 L1_N310 L2_N10 5.4051543095e+05
R_Dense_2_311_10 L1_N311 L2_N10 2.4496925668e+05
R_Dense_2_312_10 L1_N312 L2_N10 3.1402923524e+05
R_Dense_2_313_10 L1_N313 L2_N10 1.8712139279e+05
R_Dense_2_314_10 L1_N314 L2_N10 8.1072808661e+05
R_Dense_2_315_10 L1_N315 L2_N10 1.6479187666e+05
R_Dense_2_316_10 L1_N316 L2_N10 3.0741612144e+05
R_Dense_2_317_10 L1_N317 L2_N10 1.5973102351e+05
R_Dense_2_318_10 L1_N318 L2_N10 1.1604608645e+05
R_Dense_2_319_10 L1_N319 L2_N10 2.5654668062e+05
R_Dense_2_320_10 L1_N320 L2_N10 1.0488241637e+05
R_Dense_2_321_10 L1_N321 L2_N10 1.0052799277e+05
R_Dense_2_322_10 L1_N322 L2_N10 1.3255516341e+05
R_Dense_2_323_10 L1_N323 L2_N10 2.3879972995e+05
R_Dense_2_324_10 L1_N324 L2_N10 1.7230131253e+05
R_Dense_2_325_10 L1_N325 L2_N10 2.0097597592e+05
R_Dense_2_326_10 L1_N326 L2_N10 2.0449916667e+05
R_Dense_2_327_10 L1_N327 L2_N10 4.1799912544e+05
R_Dense_2_328_10 L1_N328 L2_N10 1.5095675953e+05
R_Dense_2_329_10 L1_N329 L2_N10 2.0117544871e+05
R_Dense_2_330_10 L1_N330 L2_N10 2.1561658174e+05
R_Dense_2_331_10 L1_N331 L2_N10 1.0191752215e+05
R_Dense_2_332_10 L1_N332 L2_N10 3.4653131946e+05
R_Dense_2_333_10 L1_N333 L2_N10 1.1967404604e+05
R_Dense_2_334_10 L1_N334 L2_N10 2.5898661900e+05
R_Dense_2_335_10 L1_N335 L2_N10 7.4746128100e+05
R_Dense_2_336_10 L1_N336 L2_N10 1.4035738351e+05
R_Dense_2_337_10 L1_N337 L2_N10 7.4730662325e+05
*
R_Dense_2_0_11 L1_N0 L2_N11 1.6459355044e+05
R_Dense_2_1_11 L1_N1 L2_N11 1.5551602884e+05
R_Dense_2_2_11 L1_N2 L2_N11 1.7264701638e+05
R_Dense_2_3_11 L1_N3 L2_N11 1.2941188930e+06
R_Dense_2_4_11 L1_N4 L2_N11 4.3074162303e+05
R_Dense_2_5_11 L1_N5 L2_N11 1.1743212385e+05
R_Dense_2_6_11 L1_N6 L2_N11 1.8329134091e+05
R_Dense_2_7_11 L1_N7 L2_N11 1.0254886213e+05
R_Dense_2_8_11 L1_N8 L2_N11 2.4940610450e+05
R_Dense_2_9_11 L1_N9 L2_N11 1.6067404393e+05
R_Dense_2_10_11 L1_N10 L2_N11 1.4320351248e+05
R_Dense_2_11_11 L1_N11 L2_N11 1.0282487090e+05
R_Dense_2_12_11 L1_N12 L2_N11 5.1498244546e+06
R_Dense_2_13_11 L1_N13 L2_N11 1.3579336531e+05
R_Dense_2_14_11 L1_N14 L2_N11 1.2606227524e+05
R_Dense_2_15_11 L1_N15 L2_N11 1.9614911425e+05
R_Dense_2_16_11 L1_N16 L2_N11 3.5574381328e+05
R_Dense_2_17_11 L1_N17 L2_N11 2.5793627998e+05
R_Dense_2_18_11 L1_N18 L2_N11 1.8230173206e+05
R_Dense_2_19_11 L1_N19 L2_N11 3.0328310851e+05
R_Dense_2_20_11 L1_N20 L2_N11 1.4562423148e+05
R_Dense_2_21_11 L1_N21 L2_N11 3.4192271997e+05
R_Dense_2_22_11 L1_N22 L2_N11 1.0276154085e+05
R_Dense_2_23_11 L1_N23 L2_N11 2.6109224028e+05
R_Dense_2_24_11 L1_N24 L2_N11 1.2395520900e+05
R_Dense_2_25_11 L1_N25 L2_N11 1.2198330989e+05
R_Dense_2_26_11 L1_N26 L2_N11 2.2548150005e+05
R_Dense_2_27_11 L1_N27 L2_N11 4.2786951163e+05
R_Dense_2_28_11 L1_N28 L2_N11 2.0938932330e+05
R_Dense_2_29_11 L1_N29 L2_N11 1.5790455417e+05
R_Dense_2_30_11 L1_N30 L2_N11 6.1555413584e+05
R_Dense_2_31_11 L1_N31 L2_N11 2.0305241005e+05
R_Dense_2_32_11 L1_N32 L2_N11 3.9738674190e+05
R_Dense_2_33_11 L1_N33 L2_N11 1.9146740121e+05
R_Dense_2_34_11 L1_N34 L2_N11 1.7964395855e+05
R_Dense_2_35_11 L1_N35 L2_N11 1.1426969995e+05
R_Dense_2_36_11 L1_N36 L2_N11 1.1724237196e+05
R_Dense_2_37_11 L1_N37 L2_N11 1.5805262229e+05
R_Dense_2_38_11 L1_N38 L2_N11 2.0246264278e+05
R_Dense_2_39_11 L1_N39 L2_N11 2.5637356942e+05
R_Dense_2_40_11 L1_N40 L2_N11 1.3295052971e+06
R_Dense_2_41_11 L1_N41 L2_N11 1.0126939486e+06
R_Dense_2_42_11 L1_N42 L2_N11 1.3794263866e+05
R_Dense_2_43_11 L1_N43 L2_N11 8.2818560618e+05
R_Dense_2_44_11 L1_N44 L2_N11 1.7046509840e+05
R_Dense_2_45_11 L1_N45 L2_N11 1.6664726270e+05
R_Dense_2_46_11 L1_N46 L2_N11 1.5487666075e+05
R_Dense_2_47_11 L1_N47 L2_N11 1.1203432616e+05
R_Dense_2_48_11 L1_N48 L2_N11 1.2082485794e+05
R_Dense_2_49_11 L1_N49 L2_N11 1.8778790888e+05
R_Dense_2_50_11 L1_N50 L2_N11 2.3466640495e+05
R_Dense_2_51_11 L1_N51 L2_N11 1.5584069987e+05
R_Dense_2_52_11 L1_N52 L2_N11 1.8467867706e+05
R_Dense_2_53_11 L1_N53 L2_N11 1.1477505012e+05
R_Dense_2_54_11 L1_N54 L2_N11 2.1009773275e+05
R_Dense_2_55_11 L1_N55 L2_N11 3.7571709724e+05
R_Dense_2_56_11 L1_N56 L2_N11 1.1106400817e+05
R_Dense_2_57_11 L1_N57 L2_N11 1.1726181303e+05
R_Dense_2_58_11 L1_N58 L2_N11 1.3698524536e+05
R_Dense_2_59_11 L1_N59 L2_N11 1.6020081762e+05
R_Dense_2_60_11 L1_N60 L2_N11 1.8668806930e+06
R_Dense_2_61_11 L1_N61 L2_N11 1.0104402742e+05
R_Dense_2_62_11 L1_N62 L2_N11 1.0040505579e+05
R_Dense_2_63_11 L1_N63 L2_N11 1.2202941753e+05
R_Dense_2_64_11 L1_N64 L2_N11 2.6790512476e+05
R_Dense_2_65_11 L1_N65 L2_N11 1.8976254017e+05
R_Dense_2_66_11 L1_N66 L2_N11 1.0083066530e+05
R_Dense_2_67_11 L1_N67 L2_N11 1.5206358659e+06
R_Dense_2_68_11 L1_N68 L2_N11 3.0600577576e+05
R_Dense_2_69_11 L1_N69 L2_N11 1.0134803409e+06
R_Dense_2_70_11 L1_N70 L2_N11 1.4318611591e+05
R_Dense_2_71_11 L1_N71 L2_N11 1.3428881036e+05
R_Dense_2_72_11 L1_N72 L2_N11 1.7405915292e+05
R_Dense_2_73_11 L1_N73 L2_N11 3.4010707716e+05
R_Dense_2_74_11 L1_N74 L2_N11 1.1703481892e+05
R_Dense_2_75_11 L1_N75 L2_N11 1.0011755732e+05
R_Dense_2_76_11 L1_N76 L2_N11 2.9030779126e+05
R_Dense_2_77_11 L1_N77 L2_N11 9.2096317228e+06
R_Dense_2_78_11 L1_N78 L2_N11 1.6103345699e+06
R_Dense_2_79_11 L1_N79 L2_N11 1.7848844777e+05
R_Dense_2_80_11 L1_N80 L2_N11 1.2156199396e+05
R_Dense_2_81_11 L1_N81 L2_N11 1.7819409624e+05
R_Dense_2_82_11 L1_N82 L2_N11 1.0423337954e+06
R_Dense_2_83_11 L1_N83 L2_N11 1.4102741475e+05
R_Dense_2_84_11 L1_N84 L2_N11 5.4674225723e+05
R_Dense_2_85_11 L1_N85 L2_N11 4.4492117457e+05
R_Dense_2_86_11 L1_N86 L2_N11 4.0491502014e+05
R_Dense_2_87_11 L1_N87 L2_N11 2.6215434621e+05
R_Dense_2_88_11 L1_N88 L2_N11 2.8447810030e+05
R_Dense_2_89_11 L1_N89 L2_N11 1.8797335800e+05
R_Dense_2_90_11 L1_N90 L2_N11 1.2168135477e+05
R_Dense_2_91_11 L1_N91 L2_N11 1.5380716700e+05
R_Dense_2_92_11 L1_N92 L2_N11 2.4090087458e+05
R_Dense_2_93_11 L1_N93 L2_N11 1.5356924163e+05
R_Dense_2_94_11 L1_N94 L2_N11 1.7984255424e+05
R_Dense_2_95_11 L1_N95 L2_N11 3.2708372771e+05
R_Dense_2_96_11 L1_N96 L2_N11 3.3729785251e+06
R_Dense_2_97_11 L1_N97 L2_N11 7.2252740313e+05
R_Dense_2_98_11 L1_N98 L2_N11 3.6959088937e+05
R_Dense_2_99_11 L1_N99 L2_N11 3.5996422493e+05
R_Dense_2_100_11 L1_N100 L2_N11 4.7877916955e+05
R_Dense_2_101_11 L1_N101 L2_N11 1.3030426355e+05
R_Dense_2_102_11 L1_N102 L2_N11 1.1657527133e+05
R_Dense_2_103_11 L1_N103 L2_N11 1.1849349577e+05
R_Dense_2_104_11 L1_N104 L2_N11 2.2515671703e+05
R_Dense_2_105_11 L1_N105 L2_N11 5.2305110343e+05
R_Dense_2_106_11 L1_N106 L2_N11 4.6872488579e+05
R_Dense_2_107_11 L1_N107 L2_N11 4.4009644362e+05
R_Dense_2_108_11 L1_N108 L2_N11 1.0944106197e+05
R_Dense_2_109_11 L1_N109 L2_N11 1.8038065003e+05
R_Dense_2_110_11 L1_N110 L2_N11 1.5464497011e+05
R_Dense_2_111_11 L1_N111 L2_N11 1.0181885611e+05
R_Dense_2_112_11 L1_N112 L2_N11 8.7616434872e+05
R_Dense_2_113_11 L1_N113 L2_N11 1.5027411889e+05
R_Dense_2_114_11 L1_N114 L2_N11 1.7331955403e+05
R_Dense_2_115_11 L1_N115 L2_N11 2.5800723404e+05
R_Dense_2_116_11 L1_N116 L2_N11 9.8468539843e+05
R_Dense_2_117_11 L1_N117 L2_N11 4.1077473691e+05
R_Dense_2_118_11 L1_N118 L2_N11 1.5363699894e+05
R_Dense_2_119_11 L1_N119 L2_N11 4.1586253600e+05
R_Dense_2_120_11 L1_N120 L2_N11 1.2015662713e+05
R_Dense_2_121_11 L1_N121 L2_N11 1.2587239086e+05
R_Dense_2_122_11 L1_N122 L2_N11 1.3715990634e+05
R_Dense_2_123_11 L1_N123 L2_N11 7.0348070035e+05
R_Dense_2_124_11 L1_N124 L2_N11 2.1089583494e+05
R_Dense_2_125_11 L1_N125 L2_N11 2.3790572920e+05
R_Dense_2_126_11 L1_N126 L2_N11 3.2700676613e+06
R_Dense_2_127_11 L1_N127 L2_N11 1.2144932639e+05
R_Dense_2_128_11 L1_N128 L2_N11 1.2722624958e+05
R_Dense_2_129_11 L1_N129 L2_N11 1.1423864496e+05
R_Dense_2_130_11 L1_N130 L2_N11 6.7016636648e+05
R_Dense_2_131_11 L1_N131 L2_N11 1.6504164825e+05
R_Dense_2_132_11 L1_N132 L2_N11 1.5398363187e+05
R_Dense_2_133_11 L1_N133 L2_N11 1.2570881334e+06
R_Dense_2_134_11 L1_N134 L2_N11 1.2147690810e+05
R_Dense_2_135_11 L1_N135 L2_N11 1.2188822147e+05
R_Dense_2_136_11 L1_N136 L2_N11 3.2520448595e+06
R_Dense_2_137_11 L1_N137 L2_N11 1.0921503517e+05
R_Dense_2_138_11 L1_N138 L2_N11 4.6208563985e+05
R_Dense_2_139_11 L1_N139 L2_N11 1.4474014514e+05
R_Dense_2_140_11 L1_N140 L2_N11 2.9805857600e+05
R_Dense_2_141_11 L1_N141 L2_N11 7.4681114813e+05
R_Dense_2_142_11 L1_N142 L2_N11 6.0179349340e+05
R_Dense_2_143_11 L1_N143 L2_N11 5.5314914304e+05
R_Dense_2_144_11 L1_N144 L2_N11 1.2847341929e+05
R_Dense_2_145_11 L1_N145 L2_N11 3.5314696175e+05
R_Dense_2_146_11 L1_N146 L2_N11 2.1953307386e+05
R_Dense_2_147_11 L1_N147 L2_N11 4.5685339557e+05
R_Dense_2_148_11 L1_N148 L2_N11 1.3444773195e+06
R_Dense_2_149_11 L1_N149 L2_N11 5.9499679931e+05
R_Dense_2_150_11 L1_N150 L2_N11 1.0109879824e+05
R_Dense_2_151_11 L1_N151 L2_N11 8.3575977554e+05
R_Dense_2_152_11 L1_N152 L2_N11 6.4959155901e+05
R_Dense_2_153_11 L1_N153 L2_N11 1.2330594956e+05
R_Dense_2_154_11 L1_N154 L2_N11 1.0801960568e+05
R_Dense_2_155_11 L1_N155 L2_N11 1.1443381995e+05
R_Dense_2_156_11 L1_N156 L2_N11 1.2734681484e+05
R_Dense_2_157_11 L1_N157 L2_N11 4.3806243045e+05
R_Dense_2_158_11 L1_N158 L2_N11 2.4855234803e+06
R_Dense_2_159_11 L1_N159 L2_N11 3.8079398633e+05
R_Dense_2_160_11 L1_N160 L2_N11 2.0872320029e+05
R_Dense_2_161_11 L1_N161 L2_N11 4.1226712412e+05
R_Dense_2_162_11 L1_N162 L2_N11 4.6165011979e+05
R_Dense_2_163_11 L1_N163 L2_N11 9.7913076921e+05
R_Dense_2_164_11 L1_N164 L2_N11 1.3520072964e+05
R_Dense_2_165_11 L1_N165 L2_N11 3.1457574621e+05
R_Dense_2_166_11 L1_N166 L2_N11 1.3433376676e+05
R_Dense_2_167_11 L1_N167 L2_N11 1.9266716976e+05
R_Dense_2_168_11 L1_N168 L2_N11 3.2287259229e+05
R_Dense_2_169_11 L1_N169 L2_N11 1.0380859362e+05
R_Dense_2_170_11 L1_N170 L2_N11 2.6391999067e+05
R_Dense_2_171_11 L1_N171 L2_N11 1.7303831918e+05
R_Dense_2_172_11 L1_N172 L2_N11 1.6773170422e+05
R_Dense_2_173_11 L1_N173 L2_N11 1.9803199795e+05
R_Dense_2_174_11 L1_N174 L2_N11 8.1213675804e+05
R_Dense_2_175_11 L1_N175 L2_N11 6.3743935214e+05
R_Dense_2_176_11 L1_N176 L2_N11 2.6137493589e+05
R_Dense_2_177_11 L1_N177 L2_N11 1.2298054341e+05
R_Dense_2_178_11 L1_N178 L2_N11 1.5429937440e+05
R_Dense_2_179_11 L1_N179 L2_N11 1.3919302740e+05
R_Dense_2_180_11 L1_N180 L2_N11 7.2208343625e+05
R_Dense_2_181_11 L1_N181 L2_N11 1.6977939176e+05
R_Dense_2_182_11 L1_N182 L2_N11 4.2366524541e+05
R_Dense_2_183_11 L1_N183 L2_N11 5.2277158254e+05
R_Dense_2_184_11 L1_N184 L2_N11 5.2223786096e+06
R_Dense_2_185_11 L1_N185 L2_N11 3.7813538796e+05
R_Dense_2_186_11 L1_N186 L2_N11 1.0725201565e+05
R_Dense_2_187_11 L1_N187 L2_N11 5.8780557398e+05
R_Dense_2_188_11 L1_N188 L2_N11 1.5963227479e+05
R_Dense_2_189_11 L1_N189 L2_N11 1.7289503590e+05
R_Dense_2_190_11 L1_N190 L2_N11 4.5704857759e+06
R_Dense_2_191_11 L1_N191 L2_N11 8.2229475028e+05
R_Dense_2_192_11 L1_N192 L2_N11 4.1708332011e+05
R_Dense_2_193_11 L1_N193 L2_N11 2.0645267104e+05
R_Dense_2_194_11 L1_N194 L2_N11 1.9111329702e+05
R_Dense_2_195_11 L1_N195 L2_N11 3.2875248207e+05
R_Dense_2_196_11 L1_N196 L2_N11 1.8862219444e+05
R_Dense_2_197_11 L1_N197 L2_N11 1.5715671220e+05
R_Dense_2_198_11 L1_N198 L2_N11 1.2169168438e+05
R_Dense_2_199_11 L1_N199 L2_N11 1.3219558737e+05
R_Dense_2_200_11 L1_N200 L2_N11 4.6189697310e+05
R_Dense_2_201_11 L1_N201 L2_N11 1.7427565189e+06
R_Dense_2_202_11 L1_N202 L2_N11 3.2610859775e+06
R_Dense_2_203_11 L1_N203 L2_N11 2.1683928836e+06
R_Dense_2_204_11 L1_N204 L2_N11 1.3232045489e+05
R_Dense_2_205_11 L1_N205 L2_N11 1.4449984365e+05
R_Dense_2_206_11 L1_N206 L2_N11 4.5949551045e+05
R_Dense_2_207_11 L1_N207 L2_N11 1.8008028755e+05
R_Dense_2_208_11 L1_N208 L2_N11 1.0211255046e+05
R_Dense_2_209_11 L1_N209 L2_N11 1.4655967849e+05
R_Dense_2_210_11 L1_N210 L2_N11 1.0245018950e+05
R_Dense_2_211_11 L1_N211 L2_N11 4.8496555610e+05
R_Dense_2_212_11 L1_N212 L2_N11 2.0951416245e+05
R_Dense_2_213_11 L1_N213 L2_N11 4.0757542323e+05
R_Dense_2_214_11 L1_N214 L2_N11 4.1202316618e+05
R_Dense_2_215_11 L1_N215 L2_N11 1.4399284812e+05
R_Dense_2_216_11 L1_N216 L2_N11 1.8403917711e+05
R_Dense_2_217_11 L1_N217 L2_N11 1.4113491556e+05
R_Dense_2_218_11 L1_N218 L2_N11 2.1715674150e+05
R_Dense_2_219_11 L1_N219 L2_N11 9.6673803441e+05
R_Dense_2_220_11 L1_N220 L2_N11 4.7404449381e+06
R_Dense_2_221_11 L1_N221 L2_N11 2.4781433313e+05
R_Dense_2_222_11 L1_N222 L2_N11 1.2339036544e+05
R_Dense_2_223_11 L1_N223 L2_N11 1.3120196728e+05
R_Dense_2_224_11 L1_N224 L2_N11 1.0177749073e+05
R_Dense_2_225_11 L1_N225 L2_N11 1.3159840272e+05
R_Dense_2_226_11 L1_N226 L2_N11 4.1761653185e+06
R_Dense_2_227_11 L1_N227 L2_N11 5.6166202857e+05
R_Dense_2_228_11 L1_N228 L2_N11 3.6172612622e+05
R_Dense_2_229_11 L1_N229 L2_N11 2.7494601660e+05
R_Dense_2_230_11 L1_N230 L2_N11 1.9173565102e+05
R_Dense_2_231_11 L1_N231 L2_N11 1.1639322545e+05
R_Dense_2_232_11 L1_N232 L2_N11 2.7759375899e+05
R_Dense_2_233_11 L1_N233 L2_N11 1.6768311388e+05
R_Dense_2_234_11 L1_N234 L2_N11 2.6213267610e+05
R_Dense_2_235_11 L1_N235 L2_N11 2.4592302525e+05
R_Dense_2_236_11 L1_N236 L2_N11 2.5638760619e+05
R_Dense_2_237_11 L1_N237 L2_N11 7.4685929225e+05
R_Dense_2_238_11 L1_N238 L2_N11 1.0941494486e+06
R_Dense_2_239_11 L1_N239 L2_N11 2.6019614936e+05
R_Dense_2_240_11 L1_N240 L2_N11 1.1763172943e+05
R_Dense_2_241_11 L1_N241 L2_N11 2.2183470326e+05
R_Dense_2_242_11 L1_N242 L2_N11 2.4821561100e+05
R_Dense_2_243_11 L1_N243 L2_N11 1.8093497150e+05
R_Dense_2_244_11 L1_N244 L2_N11 1.3286746735e+05
R_Dense_2_245_11 L1_N245 L2_N11 1.5111654683e+05
R_Dense_2_246_11 L1_N246 L2_N11 8.4650463685e+05
R_Dense_2_247_11 L1_N247 L2_N11 3.8090140706e+05
R_Dense_2_248_11 L1_N248 L2_N11 1.3841562805e+05
R_Dense_2_249_11 L1_N249 L2_N11 1.2713393869e+05
R_Dense_2_250_11 L1_N250 L2_N11 2.9331315696e+05
R_Dense_2_251_11 L1_N251 L2_N11 2.2572117175e+05
R_Dense_2_252_11 L1_N252 L2_N11 2.9188380561e+05
R_Dense_2_253_11 L1_N253 L2_N11 1.5436292970e+05
R_Dense_2_254_11 L1_N254 L2_N11 1.0320229180e+06
R_Dense_2_255_11 L1_N255 L2_N11 1.1145426258e+05
R_Dense_2_256_11 L1_N256 L2_N11 1.6306738955e+05
R_Dense_2_257_11 L1_N257 L2_N11 2.2920447472e+06
R_Dense_2_258_11 L1_N258 L2_N11 1.8195739494e+05
R_Dense_2_259_11 L1_N259 L2_N11 1.4308264741e+05
R_Dense_2_260_11 L1_N260 L2_N11 1.4943311105e+05
R_Dense_2_261_11 L1_N261 L2_N11 1.9469109938e+06
R_Dense_2_262_11 L1_N262 L2_N11 7.8356984624e+05
R_Dense_2_263_11 L1_N263 L2_N11 1.1640378730e+05
R_Dense_2_264_11 L1_N264 L2_N11 1.7135347272e+05
R_Dense_2_265_11 L1_N265 L2_N11 1.5052468465e+06
R_Dense_2_266_11 L1_N266 L2_N11 1.6560419526e+05
R_Dense_2_267_11 L1_N267 L2_N11 1.2333103180e+05
R_Dense_2_268_11 L1_N268 L2_N11 1.6611649488e+06
R_Dense_2_269_11 L1_N269 L2_N11 1.5392918032e+05
R_Dense_2_270_11 L1_N270 L2_N11 1.8156765804e+05
R_Dense_2_271_11 L1_N271 L2_N11 1.5912759881e+05
R_Dense_2_272_11 L1_N272 L2_N11 1.9099184205e+05
R_Dense_2_273_11 L1_N273 L2_N11 4.1870716123e+05
R_Dense_2_274_11 L1_N274 L2_N11 1.0210005014e+05
R_Dense_2_275_11 L1_N275 L2_N11 1.1254524650e+05
R_Dense_2_276_11 L1_N276 L2_N11 3.1924894054e+05
R_Dense_2_277_11 L1_N277 L2_N11 2.2087841234e+05
R_Dense_2_278_11 L1_N278 L2_N11 1.6750670528e+05
R_Dense_2_279_11 L1_N279 L2_N11 5.4158742720e+05
R_Dense_2_280_11 L1_N280 L2_N11 4.8590030006e+05
R_Dense_2_281_11 L1_N281 L2_N11 1.1749147260e+05
R_Dense_2_282_11 L1_N282 L2_N11 4.2837639350e+05
R_Dense_2_283_11 L1_N283 L2_N11 1.2140109796e+05
R_Dense_2_284_11 L1_N284 L2_N11 3.1777938384e+05
R_Dense_2_285_11 L1_N285 L2_N11 2.2022649512e+05
R_Dense_2_286_11 L1_N286 L2_N11 2.0545395956e+06
R_Dense_2_287_11 L1_N287 L2_N11 1.7652195921e+05
R_Dense_2_288_11 L1_N288 L2_N11 1.4559251854e+05
R_Dense_2_289_11 L1_N289 L2_N11 5.1040119169e+05
R_Dense_2_290_11 L1_N290 L2_N11 2.9894823816e+06
R_Dense_2_291_11 L1_N291 L2_N11 5.1212456304e+05
R_Dense_2_292_11 L1_N292 L2_N11 1.1469419361e+05
R_Dense_2_293_11 L1_N293 L2_N11 1.9736519672e+06
R_Dense_2_294_11 L1_N294 L2_N11 1.0031023998e+05
R_Dense_2_295_11 L1_N295 L2_N11 1.7489768666e+06
R_Dense_2_296_11 L1_N296 L2_N11 1.1508313817e+06
R_Dense_2_297_11 L1_N297 L2_N11 4.4099302862e+05
R_Dense_2_298_11 L1_N298 L2_N11 1.2179161632e+05
R_Dense_2_299_11 L1_N299 L2_N11 1.7045300835e+05
R_Dense_2_300_11 L1_N300 L2_N11 1.7037146383e+05
R_Dense_2_301_11 L1_N301 L2_N11 3.4238946741e+05
R_Dense_2_302_11 L1_N302 L2_N11 1.4137697469e+05
R_Dense_2_303_11 L1_N303 L2_N11 2.5009800869e+05
R_Dense_2_304_11 L1_N304 L2_N11 6.6011990660e+05
R_Dense_2_305_11 L1_N305 L2_N11 1.1529454273e+05
R_Dense_2_306_11 L1_N306 L2_N11 1.5591694684e+05
R_Dense_2_307_11 L1_N307 L2_N11 2.6473261713e+05
R_Dense_2_308_11 L1_N308 L2_N11 9.8701547143e+05
R_Dense_2_309_11 L1_N309 L2_N11 6.0894355181e+06
R_Dense_2_310_11 L1_N310 L2_N11 1.3805027628e+05
R_Dense_2_311_11 L1_N311 L2_N11 2.4819187819e+05
R_Dense_2_312_11 L1_N312 L2_N11 1.0756494076e+05
R_Dense_2_313_11 L1_N313 L2_N11 4.2439536413e+05
R_Dense_2_314_11 L1_N314 L2_N11 1.5012671288e+05
R_Dense_2_315_11 L1_N315 L2_N11 1.4201210826e+05
R_Dense_2_316_11 L1_N316 L2_N11 1.1733324646e+06
R_Dense_2_317_11 L1_N317 L2_N11 2.3769407238e+05
R_Dense_2_318_11 L1_N318 L2_N11 4.4397527139e+05
R_Dense_2_319_11 L1_N319 L2_N11 1.0958455358e+05
R_Dense_2_320_11 L1_N320 L2_N11 4.1126652239e+05
R_Dense_2_321_11 L1_N321 L2_N11 4.8723990495e+05
R_Dense_2_322_11 L1_N322 L2_N11 7.2983620248e+05
R_Dense_2_323_11 L1_N323 L2_N11 1.6914918336e+05
R_Dense_2_324_11 L1_N324 L2_N11 1.8381114883e+05
R_Dense_2_325_11 L1_N325 L2_N11 1.6496224049e+05
R_Dense_2_326_11 L1_N326 L2_N11 1.0361192948e+05
R_Dense_2_327_11 L1_N327 L2_N11 5.9133352877e+05
R_Dense_2_328_11 L1_N328 L2_N11 1.0745692822e+05
R_Dense_2_329_11 L1_N329 L2_N11 1.1294527631e+05
R_Dense_2_330_11 L1_N330 L2_N11 4.1645168444e+06
R_Dense_2_331_11 L1_N331 L2_N11 1.5341885071e+05
R_Dense_2_332_11 L1_N332 L2_N11 1.3185024171e+05
R_Dense_2_333_11 L1_N333 L2_N11 1.1157865645e+05
R_Dense_2_334_11 L1_N334 L2_N11 3.3222230215e+05
R_Dense_2_335_11 L1_N335 L2_N11 4.1894723487e+05
R_Dense_2_336_11 L1_N336 L2_N11 1.0220351454e+05
R_Dense_2_337_11 L1_N337 L2_N11 1.0914282208e+06
*
R_Dense_2_0_12 L1_N0 L2_N12 2.8107616552e+05
R_Dense_2_1_12 L1_N1 L2_N12 1.1178586868e+05
R_Dense_2_2_12 L1_N2 L2_N12 1.0634856152e+05
R_Dense_2_3_12 L1_N3 L2_N12 4.3075863768e+05
R_Dense_2_4_12 L1_N4 L2_N12 5.3368925323e+05
R_Dense_2_5_12 L1_N5 L2_N12 1.4633646284e+05
R_Dense_2_6_12 L1_N6 L2_N12 5.7608680887e+05
R_Dense_2_7_12 L1_N7 L2_N12 9.1948727230e+05
R_Dense_2_8_12 L1_N8 L2_N12 1.6993555800e+05
R_Dense_2_9_12 L1_N9 L2_N12 1.1256085827e+05
R_Dense_2_10_12 L1_N10 L2_N12 1.4841461912e+05
R_Dense_2_11_12 L1_N11 L2_N12 1.0308670763e+05
R_Dense_2_12_12 L1_N12 L2_N12 2.7336775197e+05
R_Dense_2_13_12 L1_N13 L2_N12 3.7630277966e+05
R_Dense_2_14_12 L1_N14 L2_N12 1.1255092042e+05
R_Dense_2_15_12 L1_N15 L2_N12 2.7510326194e+05
R_Dense_2_16_12 L1_N16 L2_N12 2.2784266670e+05
R_Dense_2_17_12 L1_N17 L2_N12 3.2064181533e+05
R_Dense_2_18_12 L1_N18 L2_N12 2.4424346359e+05
R_Dense_2_19_12 L1_N19 L2_N12 1.3381234894e+05
R_Dense_2_20_12 L1_N20 L2_N12 1.4769419050e+05
R_Dense_2_21_12 L1_N21 L2_N12 1.9308271990e+05
R_Dense_2_22_12 L1_N22 L2_N12 2.0383572672e+05
R_Dense_2_23_12 L1_N23 L2_N12 1.0928495972e+05
R_Dense_2_24_12 L1_N24 L2_N12 1.1043357467e+05
R_Dense_2_25_12 L1_N25 L2_N12 2.6248699922e+05
R_Dense_2_26_12 L1_N26 L2_N12 5.4883983653e+05
R_Dense_2_27_12 L1_N27 L2_N12 1.1434484110e+05
R_Dense_2_28_12 L1_N28 L2_N12 1.3568390604e+05
R_Dense_2_29_12 L1_N29 L2_N12 1.1920425727e+05
R_Dense_2_30_12 L1_N30 L2_N12 1.9919095943e+05
R_Dense_2_31_12 L1_N31 L2_N12 1.8085513616e+05
R_Dense_2_32_12 L1_N32 L2_N12 2.3129788845e+06
R_Dense_2_33_12 L1_N33 L2_N12 1.8870439263e+05
R_Dense_2_34_12 L1_N34 L2_N12 1.7033363991e+05
R_Dense_2_35_12 L1_N35 L2_N12 4.0190062796e+05
R_Dense_2_36_12 L1_N36 L2_N12 3.6367957682e+05
R_Dense_2_37_12 L1_N37 L2_N12 4.0868922905e+05
R_Dense_2_38_12 L1_N38 L2_N12 1.0002368104e+05
R_Dense_2_39_12 L1_N39 L2_N12 1.4993578047e+05
R_Dense_2_40_12 L1_N40 L2_N12 1.2468440563e+05
R_Dense_2_41_12 L1_N41 L2_N12 1.4427678122e+05
R_Dense_2_42_12 L1_N42 L2_N12 1.1128893944e+06
R_Dense_2_43_12 L1_N43 L2_N12 1.2603232068e+05
R_Dense_2_44_12 L1_N44 L2_N12 6.7757724921e+05
R_Dense_2_45_12 L1_N45 L2_N12 7.9885261772e+05
R_Dense_2_46_12 L1_N46 L2_N12 2.2355213495e+06
R_Dense_2_47_12 L1_N47 L2_N12 3.0968505831e+05
R_Dense_2_48_12 L1_N48 L2_N12 2.2602263672e+05
R_Dense_2_49_12 L1_N49 L2_N12 3.9380272382e+05
R_Dense_2_50_12 L1_N50 L2_N12 2.2861892466e+05
R_Dense_2_51_12 L1_N51 L2_N12 1.7443975874e+05
R_Dense_2_52_12 L1_N52 L2_N12 1.0151563077e+05
R_Dense_2_53_12 L1_N53 L2_N12 2.9913752070e+05
R_Dense_2_54_12 L1_N54 L2_N12 1.6409781487e+05
R_Dense_2_55_12 L1_N55 L2_N12 2.7520911904e+05
R_Dense_2_56_12 L1_N56 L2_N12 1.1381973860e+05
R_Dense_2_57_12 L1_N57 L2_N12 1.5539528837e+05
R_Dense_2_58_12 L1_N58 L2_N12 2.1963530169e+05
R_Dense_2_59_12 L1_N59 L2_N12 5.2098042496e+05
R_Dense_2_60_12 L1_N60 L2_N12 1.0010402684e+05
R_Dense_2_61_12 L1_N61 L2_N12 2.8091803667e+05
R_Dense_2_62_12 L1_N62 L2_N12 1.1989969107e+05
R_Dense_2_63_12 L1_N63 L2_N12 1.7786448768e+05
R_Dense_2_64_12 L1_N64 L2_N12 1.3605572602e+05
R_Dense_2_65_12 L1_N65 L2_N12 3.2549246761e+05
R_Dense_2_66_12 L1_N66 L2_N12 3.6382114509e+05
R_Dense_2_67_12 L1_N67 L2_N12 3.6935595135e+05
R_Dense_2_68_12 L1_N68 L2_N12 2.1970511407e+05
R_Dense_2_69_12 L1_N69 L2_N12 3.0414524807e+05
R_Dense_2_70_12 L1_N70 L2_N12 1.2111862658e+05
R_Dense_2_71_12 L1_N71 L2_N12 1.1053977364e+05
R_Dense_2_72_12 L1_N72 L2_N12 1.0262642043e+05
R_Dense_2_73_12 L1_N73 L2_N12 2.3026545785e+05
R_Dense_2_74_12 L1_N74 L2_N12 5.6147753087e+05
R_Dense_2_75_12 L1_N75 L2_N12 2.2618212291e+05
R_Dense_2_76_12 L1_N76 L2_N12 1.3664354402e+05
R_Dense_2_77_12 L1_N77 L2_N12 3.1673966920e+05
R_Dense_2_78_12 L1_N78 L2_N12 2.7481392741e+05
R_Dense_2_79_12 L1_N79 L2_N12 2.1716964978e+05
R_Dense_2_80_12 L1_N80 L2_N12 7.4166448861e+05
R_Dense_2_81_12 L1_N81 L2_N12 1.7119846222e+05
R_Dense_2_82_12 L1_N82 L2_N12 1.5310301996e+05
R_Dense_2_83_12 L1_N83 L2_N12 1.3309248755e+05
R_Dense_2_84_12 L1_N84 L2_N12 5.2615213374e+06
R_Dense_2_85_12 L1_N85 L2_N12 1.5681572947e+05
R_Dense_2_86_12 L1_N86 L2_N12 3.2968308366e+05
R_Dense_2_87_12 L1_N87 L2_N12 1.1672989135e+05
R_Dense_2_88_12 L1_N88 L2_N12 3.1523774114e+05
R_Dense_2_89_12 L1_N89 L2_N12 2.2504014463e+05
R_Dense_2_90_12 L1_N90 L2_N12 4.8762675512e+05
R_Dense_2_91_12 L1_N91 L2_N12 1.9837262180e+05
R_Dense_2_92_12 L1_N92 L2_N12 4.0713157996e+05
R_Dense_2_93_12 L1_N93 L2_N12 2.2556387739e+05
R_Dense_2_94_12 L1_N94 L2_N12 2.2931836567e+05
R_Dense_2_95_12 L1_N95 L2_N12 2.3273535722e+05
R_Dense_2_96_12 L1_N96 L2_N12 3.3592004151e+05
R_Dense_2_97_12 L1_N97 L2_N12 1.0877270898e+05
R_Dense_2_98_12 L1_N98 L2_N12 2.1684136375e+05
R_Dense_2_99_12 L1_N99 L2_N12 1.2514732668e+05
R_Dense_2_100_12 L1_N100 L2_N12 3.7507645763e+05
R_Dense_2_101_12 L1_N101 L2_N12 5.7730195198e+05
R_Dense_2_102_12 L1_N102 L2_N12 3.5667818695e+05
R_Dense_2_103_12 L1_N103 L2_N12 1.0533728716e+05
R_Dense_2_104_12 L1_N104 L2_N12 1.2044862242e+05
R_Dense_2_105_12 L1_N105 L2_N12 8.1526139772e+05
R_Dense_2_106_12 L1_N106 L2_N12 1.8934596226e+06
R_Dense_2_107_12 L1_N107 L2_N12 2.2272414303e+05
R_Dense_2_108_12 L1_N108 L2_N12 2.2143712432e+05
R_Dense_2_109_12 L1_N109 L2_N12 1.5029188891e+05
R_Dense_2_110_12 L1_N110 L2_N12 2.0434973072e+05
R_Dense_2_111_12 L1_N111 L2_N12 1.6424820560e+05
R_Dense_2_112_12 L1_N112 L2_N12 2.0129063669e+05
R_Dense_2_113_12 L1_N113 L2_N12 3.5892684059e+05
R_Dense_2_114_12 L1_N114 L2_N12 1.4856712599e+05
R_Dense_2_115_12 L1_N115 L2_N12 1.1218751949e+06
R_Dense_2_116_12 L1_N116 L2_N12 1.7403918093e+05
R_Dense_2_117_12 L1_N117 L2_N12 3.4887832531e+05
R_Dense_2_118_12 L1_N118 L2_N12 9.1459326726e+05
R_Dense_2_119_12 L1_N119 L2_N12 2.6582490652e+05
R_Dense_2_120_12 L1_N120 L2_N12 1.2585569151e+06
R_Dense_2_121_12 L1_N121 L2_N12 1.1168531491e+06
R_Dense_2_122_12 L1_N122 L2_N12 1.7444536183e+05
R_Dense_2_123_12 L1_N123 L2_N12 1.3078494682e+05
R_Dense_2_124_12 L1_N124 L2_N12 1.1088739902e+05
R_Dense_2_125_12 L1_N125 L2_N12 1.5020070256e+05
R_Dense_2_126_12 L1_N126 L2_N12 1.1839987491e+05
R_Dense_2_127_12 L1_N127 L2_N12 5.6741524024e+05
R_Dense_2_128_12 L1_N128 L2_N12 1.3287411574e+05
R_Dense_2_129_12 L1_N129 L2_N12 1.3790846706e+05
R_Dense_2_130_12 L1_N130 L2_N12 3.8003279565e+05
R_Dense_2_131_12 L1_N131 L2_N12 1.0435051497e+05
R_Dense_2_132_12 L1_N132 L2_N12 1.3230785503e+05
R_Dense_2_133_12 L1_N133 L2_N12 4.0413355972e+05
R_Dense_2_134_12 L1_N134 L2_N12 1.5530079626e+05
R_Dense_2_135_12 L1_N135 L2_N12 1.3303411807e+05
R_Dense_2_136_12 L1_N136 L2_N12 1.4912757963e+05
R_Dense_2_137_12 L1_N137 L2_N12 1.3811919252e+05
R_Dense_2_138_12 L1_N138 L2_N12 3.2297219672e+05
R_Dense_2_139_12 L1_N139 L2_N12 1.5068448327e+05
R_Dense_2_140_12 L1_N140 L2_N12 3.6715944072e+05
R_Dense_2_141_12 L1_N141 L2_N12 1.5520571468e+05
R_Dense_2_142_12 L1_N142 L2_N12 4.7320721594e+05
R_Dense_2_143_12 L1_N143 L2_N12 2.1672604442e+05
R_Dense_2_144_12 L1_N144 L2_N12 5.7291022500e+05
R_Dense_2_145_12 L1_N145 L2_N12 2.7573270512e+05
R_Dense_2_146_12 L1_N146 L2_N12 2.2970967199e+05
R_Dense_2_147_12 L1_N147 L2_N12 1.0817586750e+06
R_Dense_2_148_12 L1_N148 L2_N12 1.8641315214e+05
R_Dense_2_149_12 L1_N149 L2_N12 4.3094130759e+05
R_Dense_2_150_12 L1_N150 L2_N12 5.0363638136e+05
R_Dense_2_151_12 L1_N151 L2_N12 7.5099655641e+05
R_Dense_2_152_12 L1_N152 L2_N12 1.3543864311e+05
R_Dense_2_153_12 L1_N153 L2_N12 1.5442194398e+05
R_Dense_2_154_12 L1_N154 L2_N12 2.2965323604e+05
R_Dense_2_155_12 L1_N155 L2_N12 2.5428553779e+05
R_Dense_2_156_12 L1_N156 L2_N12 9.4538843737e+05
R_Dense_2_157_12 L1_N157 L2_N12 2.3742962671e+05
R_Dense_2_158_12 L1_N158 L2_N12 1.2029109161e+06
R_Dense_2_159_12 L1_N159 L2_N12 1.9176309093e+05
R_Dense_2_160_12 L1_N160 L2_N12 2.4337748344e+05
R_Dense_2_161_12 L1_N161 L2_N12 2.0010737708e+05
R_Dense_2_162_12 L1_N162 L2_N12 1.0417370079e+05
R_Dense_2_163_12 L1_N163 L2_N12 1.0590703633e+05
R_Dense_2_164_12 L1_N164 L2_N12 1.0282282748e+05
R_Dense_2_165_12 L1_N165 L2_N12 7.4573926183e+05
R_Dense_2_166_12 L1_N166 L2_N12 2.0922419574e+05
R_Dense_2_167_12 L1_N167 L2_N12 1.0687358734e+05
R_Dense_2_168_12 L1_N168 L2_N12 1.1241552518e+05
R_Dense_2_169_12 L1_N169 L2_N12 1.0279893832e+05
R_Dense_2_170_12 L1_N170 L2_N12 2.6263509068e+06
R_Dense_2_171_12 L1_N171 L2_N12 1.0861662335e+05
R_Dense_2_172_12 L1_N172 L2_N12 1.1778817606e+05
R_Dense_2_173_12 L1_N173 L2_N12 1.1440924133e+06
R_Dense_2_174_12 L1_N174 L2_N12 3.2436149042e+05
R_Dense_2_175_12 L1_N175 L2_N12 2.6633862789e+05
R_Dense_2_176_12 L1_N176 L2_N12 1.5199526004e+05
R_Dense_2_177_12 L1_N177 L2_N12 2.7845812749e+05
R_Dense_2_178_12 L1_N178 L2_N12 1.2178342326e+06
R_Dense_2_179_12 L1_N179 L2_N12 1.4641517516e+05
R_Dense_2_180_12 L1_N180 L2_N12 1.1124256055e+05
R_Dense_2_181_12 L1_N181 L2_N12 2.7892080365e+05
R_Dense_2_182_12 L1_N182 L2_N12 2.6048276794e+05
R_Dense_2_183_12 L1_N183 L2_N12 4.3722638821e+05
R_Dense_2_184_12 L1_N184 L2_N12 1.7285983449e+05
R_Dense_2_185_12 L1_N185 L2_N12 1.2712177943e+05
R_Dense_2_186_12 L1_N186 L2_N12 1.3948375738e+06
R_Dense_2_187_12 L1_N187 L2_N12 2.3932420762e+06
R_Dense_2_188_12 L1_N188 L2_N12 1.2488704677e+05
R_Dense_2_189_12 L1_N189 L2_N12 1.6938227967e+05
R_Dense_2_190_12 L1_N190 L2_N12 3.3519848571e+05
R_Dense_2_191_12 L1_N191 L2_N12 3.5865202865e+05
R_Dense_2_192_12 L1_N192 L2_N12 1.0896455235e+05
R_Dense_2_193_12 L1_N193 L2_N12 2.2899391961e+05
R_Dense_2_194_12 L1_N194 L2_N12 1.2799908873e+05
R_Dense_2_195_12 L1_N195 L2_N12 9.8237140181e+06
R_Dense_2_196_12 L1_N196 L2_N12 1.1938408336e+05
R_Dense_2_197_12 L1_N197 L2_N12 1.0117933921e+05
R_Dense_2_198_12 L1_N198 L2_N12 1.5822034260e+05
R_Dense_2_199_12 L1_N199 L2_N12 3.4344370415e+05
R_Dense_2_200_12 L1_N200 L2_N12 3.3654539760e+05
R_Dense_2_201_12 L1_N201 L2_N12 1.2705719915e+05
R_Dense_2_202_12 L1_N202 L2_N12 2.9923813043e+05
R_Dense_2_203_12 L1_N203 L2_N12 2.4374560933e+05
R_Dense_2_204_12 L1_N204 L2_N12 1.3015478165e+05
R_Dense_2_205_12 L1_N205 L2_N12 1.1022553703e+05
R_Dense_2_206_12 L1_N206 L2_N12 1.0443329354e+05
R_Dense_2_207_12 L1_N207 L2_N12 2.4062810613e+06
R_Dense_2_208_12 L1_N208 L2_N12 1.1331365625e+05
R_Dense_2_209_12 L1_N209 L2_N12 1.6769856632e+05
R_Dense_2_210_12 L1_N210 L2_N12 1.4817552308e+05
R_Dense_2_211_12 L1_N211 L2_N12 2.6418175298e+05
R_Dense_2_212_12 L1_N212 L2_N12 2.3252914324e+05
R_Dense_2_213_12 L1_N213 L2_N12 1.3486492282e+05
R_Dense_2_214_12 L1_N214 L2_N12 1.1736917778e+05
R_Dense_2_215_12 L1_N215 L2_N12 1.5688039046e+05
R_Dense_2_216_12 L1_N216 L2_N12 1.0561298141e+05
R_Dense_2_217_12 L1_N217 L2_N12 1.2190585984e+05
R_Dense_2_218_12 L1_N218 L2_N12 2.1102518583e+05
R_Dense_2_219_12 L1_N219 L2_N12 1.6167800258e+06
R_Dense_2_220_12 L1_N220 L2_N12 6.9544636165e+05
R_Dense_2_221_12 L1_N221 L2_N12 3.1727796002e+06
R_Dense_2_222_12 L1_N222 L2_N12 2.7693547098e+05
R_Dense_2_223_12 L1_N223 L2_N12 1.8246630568e+05
R_Dense_2_224_12 L1_N224 L2_N12 1.9285477140e+05
R_Dense_2_225_12 L1_N225 L2_N12 1.0378221160e+05
R_Dense_2_226_12 L1_N226 L2_N12 1.0266945038e+05
R_Dense_2_227_12 L1_N227 L2_N12 8.6932188082e+05
R_Dense_2_228_12 L1_N228 L2_N12 1.5525757687e+05
R_Dense_2_229_12 L1_N229 L2_N12 1.2613682268e+05
R_Dense_2_230_12 L1_N230 L2_N12 2.4517396827e+05
R_Dense_2_231_12 L1_N231 L2_N12 4.6706459090e+05
R_Dense_2_232_12 L1_N232 L2_N12 7.6134542016e+05
R_Dense_2_233_12 L1_N233 L2_N12 2.2838058932e+05
R_Dense_2_234_12 L1_N234 L2_N12 3.5648499146e+05
R_Dense_2_235_12 L1_N235 L2_N12 4.2267100295e+05
R_Dense_2_236_12 L1_N236 L2_N12 1.7126872709e+05
R_Dense_2_237_12 L1_N237 L2_N12 1.7862882214e+05
R_Dense_2_238_12 L1_N238 L2_N12 2.2692373548e+05
R_Dense_2_239_12 L1_N239 L2_N12 1.6924493833e+05
R_Dense_2_240_12 L1_N240 L2_N12 1.0041157629e+05
R_Dense_2_241_12 L1_N241 L2_N12 2.7668495285e+05
R_Dense_2_242_12 L1_N242 L2_N12 1.8215504976e+05
R_Dense_2_243_12 L1_N243 L2_N12 1.2161635035e+05
R_Dense_2_244_12 L1_N244 L2_N12 5.2191985202e+05
R_Dense_2_245_12 L1_N245 L2_N12 1.1889787709e+05
R_Dense_2_246_12 L1_N246 L2_N12 2.1520567503e+05
R_Dense_2_247_12 L1_N247 L2_N12 1.2608151511e+05
R_Dense_2_248_12 L1_N248 L2_N12 1.4474680490e+05
R_Dense_2_249_12 L1_N249 L2_N12 1.2290087503e+05
R_Dense_2_250_12 L1_N250 L2_N12 1.3274123923e+05
R_Dense_2_251_12 L1_N251 L2_N12 1.4443597920e+05
R_Dense_2_252_12 L1_N252 L2_N12 1.2860293449e+06
R_Dense_2_253_12 L1_N253 L2_N12 1.1654175518e+06
R_Dense_2_254_12 L1_N254 L2_N12 1.1337233479e+05
R_Dense_2_255_12 L1_N255 L2_N12 3.7489541149e+05
R_Dense_2_256_12 L1_N256 L2_N12 7.6751820708e+05
R_Dense_2_257_12 L1_N257 L2_N12 1.7116409748e+05
R_Dense_2_258_12 L1_N258 L2_N12 2.4714652901e+05
R_Dense_2_259_12 L1_N259 L2_N12 6.6771895788e+05
R_Dense_2_260_12 L1_N260 L2_N12 1.4480956395e+06
R_Dense_2_261_12 L1_N261 L2_N12 3.7365289600e+05
R_Dense_2_262_12 L1_N262 L2_N12 4.6766531027e+05
R_Dense_2_263_12 L1_N263 L2_N12 6.8049809488e+06
R_Dense_2_264_12 L1_N264 L2_N12 1.4535206750e+05
R_Dense_2_265_12 L1_N265 L2_N12 2.1810757812e+05
R_Dense_2_266_12 L1_N266 L2_N12 1.5251235709e+05
R_Dense_2_267_12 L1_N267 L2_N12 5.2067445900e+05
R_Dense_2_268_12 L1_N268 L2_N12 1.4300747200e+06
R_Dense_2_269_12 L1_N269 L2_N12 1.0947126035e+06
R_Dense_2_270_12 L1_N270 L2_N12 1.5099215602e+05
R_Dense_2_271_12 L1_N271 L2_N12 1.6308311643e+05
R_Dense_2_272_12 L1_N272 L2_N12 2.4737162862e+05
R_Dense_2_273_12 L1_N273 L2_N12 1.2087205018e+05
R_Dense_2_274_12 L1_N274 L2_N12 1.0274368844e+05
R_Dense_2_275_12 L1_N275 L2_N12 1.5873577525e+05
R_Dense_2_276_12 L1_N276 L2_N12 3.1317124858e+05
R_Dense_2_277_12 L1_N277 L2_N12 2.1814348811e+05
R_Dense_2_278_12 L1_N278 L2_N12 9.4767137211e+05
R_Dense_2_279_12 L1_N279 L2_N12 6.0663527587e+05
R_Dense_2_280_12 L1_N280 L2_N12 6.5048951056e+05
R_Dense_2_281_12 L1_N281 L2_N12 1.3479932027e+05
R_Dense_2_282_12 L1_N282 L2_N12 3.7908825253e+05
R_Dense_2_283_12 L1_N283 L2_N12 1.3394525344e+05
R_Dense_2_284_12 L1_N284 L2_N12 2.8486973373e+05
R_Dense_2_285_12 L1_N285 L2_N12 1.5036061777e+05
R_Dense_2_286_12 L1_N286 L2_N12 1.2248232953e+05
R_Dense_2_287_12 L1_N287 L2_N12 1.0744061905e+06
R_Dense_2_288_12 L1_N288 L2_N12 1.5414265207e+05
R_Dense_2_289_12 L1_N289 L2_N12 1.6013463931e+05
R_Dense_2_290_12 L1_N290 L2_N12 2.4901560252e+05
R_Dense_2_291_12 L1_N291 L2_N12 6.4360959285e+05
R_Dense_2_292_12 L1_N292 L2_N12 2.3461730429e+05
R_Dense_2_293_12 L1_N293 L2_N12 1.9319286004e+05
R_Dense_2_294_12 L1_N294 L2_N12 2.2212155474e+05
R_Dense_2_295_12 L1_N295 L2_N12 2.2448269678e+06
R_Dense_2_296_12 L1_N296 L2_N12 3.7220247848e+05
R_Dense_2_297_12 L1_N297 L2_N12 1.0951936237e+05
R_Dense_2_298_12 L1_N298 L2_N12 1.0350254676e+05
R_Dense_2_299_12 L1_N299 L2_N12 8.6208710417e+05
R_Dense_2_300_12 L1_N300 L2_N12 5.6079327912e+05
R_Dense_2_301_12 L1_N301 L2_N12 2.8652608058e+06
R_Dense_2_302_12 L1_N302 L2_N12 1.9086720445e+06
R_Dense_2_303_12 L1_N303 L2_N12 5.5352647438e+05
R_Dense_2_304_12 L1_N304 L2_N12 1.0365634588e+05
R_Dense_2_305_12 L1_N305 L2_N12 6.1654071724e+05
R_Dense_2_306_12 L1_N306 L2_N12 1.5635342307e+05
R_Dense_2_307_12 L1_N307 L2_N12 5.3862910675e+05
R_Dense_2_308_12 L1_N308 L2_N12 3.9891185848e+05
R_Dense_2_309_12 L1_N309 L2_N12 1.0790615185e+05
R_Dense_2_310_12 L1_N310 L2_N12 1.1708398340e+05
R_Dense_2_311_12 L1_N311 L2_N12 1.0647137654e+05
R_Dense_2_312_12 L1_N312 L2_N12 4.1493936667e+05
R_Dense_2_313_12 L1_N313 L2_N12 2.2829032679e+05
R_Dense_2_314_12 L1_N314 L2_N12 1.5585802703e+05
R_Dense_2_315_12 L1_N315 L2_N12 1.7545212243e+05
R_Dense_2_316_12 L1_N316 L2_N12 1.0488968458e+05
R_Dense_2_317_12 L1_N317 L2_N12 3.3579458348e+05
R_Dense_2_318_12 L1_N318 L2_N12 4.7282350024e+05
R_Dense_2_319_12 L1_N319 L2_N12 1.2526678710e+05
R_Dense_2_320_12 L1_N320 L2_N12 6.8883313837e+05
R_Dense_2_321_12 L1_N321 L2_N12 2.3159567412e+05
R_Dense_2_322_12 L1_N322 L2_N12 6.2558540108e+05
R_Dense_2_323_12 L1_N323 L2_N12 1.4013670728e+05
R_Dense_2_324_12 L1_N324 L2_N12 1.2886833796e+05
R_Dense_2_325_12 L1_N325 L2_N12 5.8783015014e+05
R_Dense_2_326_12 L1_N326 L2_N12 3.8679970123e+05
R_Dense_2_327_12 L1_N327 L2_N12 2.0068666753e+05
R_Dense_2_328_12 L1_N328 L2_N12 6.6385739276e+05
R_Dense_2_329_12 L1_N329 L2_N12 4.5983070135e+05
R_Dense_2_330_12 L1_N330 L2_N12 2.5185659740e+05
R_Dense_2_331_12 L1_N331 L2_N12 2.6295620290e+05
R_Dense_2_332_12 L1_N332 L2_N12 2.5404544102e+05
R_Dense_2_333_12 L1_N333 L2_N12 2.5232050848e+05
R_Dense_2_334_12 L1_N334 L2_N12 4.5574205371e+05
R_Dense_2_335_12 L1_N335 L2_N12 1.4916244225e+05
R_Dense_2_336_12 L1_N336 L2_N12 2.4860637563e+05
R_Dense_2_337_12 L1_N337 L2_N12 3.2569854693e+05
*
R_Dense_2_0_13 L1_N0 L2_N13 1.1252259465e+05
R_Dense_2_1_13 L1_N1 L2_N13 2.3286254889e+05
R_Dense_2_2_13 L1_N2 L2_N13 2.0270780974e+05
R_Dense_2_3_13 L1_N3 L2_N13 3.9706156011e+05
R_Dense_2_4_13 L1_N4 L2_N13 1.2981317979e+05
R_Dense_2_5_13 L1_N5 L2_N13 1.2190754315e+05
R_Dense_2_6_13 L1_N6 L2_N13 6.1140063745e+06
R_Dense_2_7_13 L1_N7 L2_N13 1.2342893224e+05
R_Dense_2_8_13 L1_N8 L2_N13 2.8461025606e+05
R_Dense_2_9_13 L1_N9 L2_N13 1.3022854419e+05
R_Dense_2_10_13 L1_N10 L2_N13 1.2446166096e+05
R_Dense_2_11_13 L1_N11 L2_N13 1.8675014140e+05
R_Dense_2_12_13 L1_N12 L2_N13 5.8534045862e+05
R_Dense_2_13_13 L1_N13 L2_N13 1.4483125537e+06
R_Dense_2_14_13 L1_N14 L2_N13 1.3409726550e+05
R_Dense_2_15_13 L1_N15 L2_N13 3.9248553579e+05
R_Dense_2_16_13 L1_N16 L2_N13 1.1017819692e+06
R_Dense_2_17_13 L1_N17 L2_N13 2.6810519109e+05
R_Dense_2_18_13 L1_N18 L2_N13 1.1768101456e+05
R_Dense_2_19_13 L1_N19 L2_N13 6.5156677501e+05
R_Dense_2_20_13 L1_N20 L2_N13 2.5295454291e+05
R_Dense_2_21_13 L1_N21 L2_N13 1.3760614236e+05
R_Dense_2_22_13 L1_N22 L2_N13 3.1218199523e+05
R_Dense_2_23_13 L1_N23 L2_N13 1.1503133298e+06
R_Dense_2_24_13 L1_N24 L2_N13 1.3496155639e+05
R_Dense_2_25_13 L1_N25 L2_N13 9.5161145503e+05
R_Dense_2_26_13 L1_N26 L2_N13 1.0261080883e+05
R_Dense_2_27_13 L1_N27 L2_N13 1.8688468987e+05
R_Dense_2_28_13 L1_N28 L2_N13 1.7352353978e+05
R_Dense_2_29_13 L1_N29 L2_N13 3.2882581112e+05
R_Dense_2_30_13 L1_N30 L2_N13 3.8934936698e+05
R_Dense_2_31_13 L1_N31 L2_N13 1.0518801707e+05
R_Dense_2_32_13 L1_N32 L2_N13 6.5488888102e+05
R_Dense_2_33_13 L1_N33 L2_N13 3.8492764252e+05
R_Dense_2_34_13 L1_N34 L2_N13 1.8715279271e+05
R_Dense_2_35_13 L1_N35 L2_N13 3.0976164133e+05
R_Dense_2_36_13 L1_N36 L2_N13 1.0632433461e+05
R_Dense_2_37_13 L1_N37 L2_N13 6.8952280463e+06
R_Dense_2_38_13 L1_N38 L2_N13 1.0471040309e+05
R_Dense_2_39_13 L1_N39 L2_N13 2.4864857674e+05
R_Dense_2_40_13 L1_N40 L2_N13 3.6685975521e+05
R_Dense_2_41_13 L1_N41 L2_N13 2.2669387607e+06
R_Dense_2_42_13 L1_N42 L2_N13 1.5970391668e+05
R_Dense_2_43_13 L1_N43 L2_N13 1.0303440655e+05
R_Dense_2_44_13 L1_N44 L2_N13 1.2104918993e+05
R_Dense_2_45_13 L1_N45 L2_N13 1.2751155205e+05
R_Dense_2_46_13 L1_N46 L2_N13 1.6127559724e+05
R_Dense_2_47_13 L1_N47 L2_N13 1.3614636619e+05
R_Dense_2_48_13 L1_N48 L2_N13 1.1353078135e+05
R_Dense_2_49_13 L1_N49 L2_N13 2.8347320679e+05
R_Dense_2_50_13 L1_N50 L2_N13 1.1164580268e+05
R_Dense_2_51_13 L1_N51 L2_N13 2.7453099122e+05
R_Dense_2_52_13 L1_N52 L2_N13 1.0519357435e+05
R_Dense_2_53_13 L1_N53 L2_N13 2.2788779936e+05
R_Dense_2_54_13 L1_N54 L2_N13 3.9665586862e+05
R_Dense_2_55_13 L1_N55 L2_N13 2.5722548631e+05
R_Dense_2_56_13 L1_N56 L2_N13 1.1396932466e+05
R_Dense_2_57_13 L1_N57 L2_N13 1.5203708235e+05
R_Dense_2_58_13 L1_N58 L2_N13 2.2592058831e+05
R_Dense_2_59_13 L1_N59 L2_N13 6.1910150993e+05
R_Dense_2_60_13 L1_N60 L2_N13 7.4759309293e+05
R_Dense_2_61_13 L1_N61 L2_N13 1.9661013035e+05
R_Dense_2_62_13 L1_N62 L2_N13 2.2531315127e+05
R_Dense_2_63_13 L1_N63 L2_N13 1.0268513615e+05
R_Dense_2_64_13 L1_N64 L2_N13 1.3900968518e+05
R_Dense_2_65_13 L1_N65 L2_N13 1.3506964317e+05
R_Dense_2_66_13 L1_N66 L2_N13 1.1717383381e+05
R_Dense_2_67_13 L1_N67 L2_N13 2.2730557193e+05
R_Dense_2_68_13 L1_N68 L2_N13 2.9507441716e+05
R_Dense_2_69_13 L1_N69 L2_N13 1.2645381974e+05
R_Dense_2_70_13 L1_N70 L2_N13 9.4787178970e+06
R_Dense_2_71_13 L1_N71 L2_N13 1.0261635876e+05
R_Dense_2_72_13 L1_N72 L2_N13 1.3044607904e+05
R_Dense_2_73_13 L1_N73 L2_N13 1.5827001377e+05
R_Dense_2_74_13 L1_N74 L2_N13 3.0718407813e+06
R_Dense_2_75_13 L1_N75 L2_N13 1.6812678752e+05
R_Dense_2_76_13 L1_N76 L2_N13 8.0407860065e+05
R_Dense_2_77_13 L1_N77 L2_N13 1.5520736438e+05
R_Dense_2_78_13 L1_N78 L2_N13 1.3835417887e+05
R_Dense_2_79_13 L1_N79 L2_N13 2.6320503566e+05
R_Dense_2_80_13 L1_N80 L2_N13 4.3350439039e+05
R_Dense_2_81_13 L1_N81 L2_N13 6.1092361042e+05
R_Dense_2_82_13 L1_N82 L2_N13 1.0370095442e+05
R_Dense_2_83_13 L1_N83 L2_N13 1.0754784269e+05
R_Dense_2_84_13 L1_N84 L2_N13 5.0266426059e+05
R_Dense_2_85_13 L1_N85 L2_N13 1.9319531493e+05
R_Dense_2_86_13 L1_N86 L2_N13 1.0136948703e+05
R_Dense_2_87_13 L1_N87 L2_N13 1.2248042853e+05
R_Dense_2_88_13 L1_N88 L2_N13 1.0519198401e+05
R_Dense_2_89_13 L1_N89 L2_N13 1.2723303710e+05
R_Dense_2_90_13 L1_N90 L2_N13 3.4257003302e+05
R_Dense_2_91_13 L1_N91 L2_N13 1.2675244836e+05
R_Dense_2_92_13 L1_N92 L2_N13 1.1942692806e+05
R_Dense_2_93_13 L1_N93 L2_N13 1.7539880117e+05
R_Dense_2_94_13 L1_N94 L2_N13 5.5743161551e+05
R_Dense_2_95_13 L1_N95 L2_N13 1.2821157297e+05
R_Dense_2_96_13 L1_N96 L2_N13 6.1563282102e+05
R_Dense_2_97_13 L1_N97 L2_N13 1.9639029122e+05
R_Dense_2_98_13 L1_N98 L2_N13 1.4240713571e+05
R_Dense_2_99_13 L1_N99 L2_N13 1.6450972096e+05
R_Dense_2_100_13 L1_N100 L2_N13 6.2850380993e+05
R_Dense_2_101_13 L1_N101 L2_N13 1.9715078620e+05
R_Dense_2_102_13 L1_N102 L2_N13 4.4490059478e+05
R_Dense_2_103_13 L1_N103 L2_N13 1.2727050469e+05
R_Dense_2_104_13 L1_N104 L2_N13 1.1187735581e+05
R_Dense_2_105_13 L1_N105 L2_N13 3.1418990466e+05
R_Dense_2_106_13 L1_N106 L2_N13 2.7835065931e+05
R_Dense_2_107_13 L1_N107 L2_N13 9.2116479769e+05
R_Dense_2_108_13 L1_N108 L2_N13 1.0239049987e+05
R_Dense_2_109_13 L1_N109 L2_N13 2.2695323555e+05
R_Dense_2_110_13 L1_N110 L2_N13 1.8012433492e+05
R_Dense_2_111_13 L1_N111 L2_N13 1.0519773363e+05
R_Dense_2_112_13 L1_N112 L2_N13 1.2679415070e+05
R_Dense_2_113_13 L1_N113 L2_N13 2.5590090447e+05
R_Dense_2_114_13 L1_N114 L2_N13 1.3388159208e+05
R_Dense_2_115_13 L1_N115 L2_N13 2.6675411759e+05
R_Dense_2_116_13 L1_N116 L2_N13 1.6017195299e+05
R_Dense_2_117_13 L1_N117 L2_N13 1.6628541454e+05
R_Dense_2_118_13 L1_N118 L2_N13 1.9310310513e+06
R_Dense_2_119_13 L1_N119 L2_N13 4.5561908787e+05
R_Dense_2_120_13 L1_N120 L2_N13 1.7848285028e+05
R_Dense_2_121_13 L1_N121 L2_N13 3.3233159195e+05
R_Dense_2_122_13 L1_N122 L2_N13 1.0300046261e+05
R_Dense_2_123_13 L1_N123 L2_N13 1.4104384002e+05
R_Dense_2_124_13 L1_N124 L2_N13 1.2762715200e+05
R_Dense_2_125_13 L1_N125 L2_N13 5.3528406313e+05
R_Dense_2_126_13 L1_N126 L2_N13 1.8419949904e+05
R_Dense_2_127_13 L1_N127 L2_N13 7.2356004468e+05
R_Dense_2_128_13 L1_N128 L2_N13 7.2821949699e+05
R_Dense_2_129_13 L1_N129 L2_N13 5.3005137575e+06
R_Dense_2_130_13 L1_N130 L2_N13 7.8123722591e+05
R_Dense_2_131_13 L1_N131 L2_N13 1.8200942331e+05
R_Dense_2_132_13 L1_N132 L2_N13 4.8364431182e+05
R_Dense_2_133_13 L1_N133 L2_N13 1.4135453683e+05
R_Dense_2_134_13 L1_N134 L2_N13 1.1203645394e+05
R_Dense_2_135_13 L1_N135 L2_N13 2.4313966346e+05
R_Dense_2_136_13 L1_N136 L2_N13 2.0360715953e+05
R_Dense_2_137_13 L1_N137 L2_N13 1.7527200742e+05
R_Dense_2_138_13 L1_N138 L2_N13 3.0376227169e+05
R_Dense_2_139_13 L1_N139 L2_N13 1.7085871564e+05
R_Dense_2_140_13 L1_N140 L2_N13 1.9005699068e+05
R_Dense_2_141_13 L1_N141 L2_N13 3.5638295467e+05
R_Dense_2_142_13 L1_N142 L2_N13 2.0082150168e+05
R_Dense_2_143_13 L1_N143 L2_N13 8.5715401372e+05
R_Dense_2_144_13 L1_N144 L2_N13 1.7990361058e+06
R_Dense_2_145_13 L1_N145 L2_N13 3.9751166485e+05
R_Dense_2_146_13 L1_N146 L2_N13 3.1036036230e+05
R_Dense_2_147_13 L1_N147 L2_N13 1.4592428790e+05
R_Dense_2_148_13 L1_N148 L2_N13 4.6515651654e+05
R_Dense_2_149_13 L1_N149 L2_N13 1.1540687353e+05
R_Dense_2_150_13 L1_N150 L2_N13 1.2409863626e+05
R_Dense_2_151_13 L1_N151 L2_N13 1.1908246400e+05
R_Dense_2_152_13 L1_N152 L2_N13 1.6992880681e+05
R_Dense_2_153_13 L1_N153 L2_N13 1.5102775871e+05
R_Dense_2_154_13 L1_N154 L2_N13 1.9376041905e+05
R_Dense_2_155_13 L1_N155 L2_N13 1.3218765233e+05
R_Dense_2_156_13 L1_N156 L2_N13 1.0894885718e+05
R_Dense_2_157_13 L1_N157 L2_N13 2.5690106011e+05
R_Dense_2_158_13 L1_N158 L2_N13 1.6237505715e+05
R_Dense_2_159_13 L1_N159 L2_N13 2.5998553055e+05
R_Dense_2_160_13 L1_N160 L2_N13 2.1332892179e+05
R_Dense_2_161_13 L1_N161 L2_N13 1.9323936868e+05
R_Dense_2_162_13 L1_N162 L2_N13 1.0449611699e+05
R_Dense_2_163_13 L1_N163 L2_N13 2.2137111899e+05
R_Dense_2_164_13 L1_N164 L2_N13 2.9850752737e+05
R_Dense_2_165_13 L1_N165 L2_N13 4.8414479086e+05
R_Dense_2_166_13 L1_N166 L2_N13 1.0226789494e+05
R_Dense_2_167_13 L1_N167 L2_N13 5.2243501666e+05
R_Dense_2_168_13 L1_N168 L2_N13 1.1249679894e+06
R_Dense_2_169_13 L1_N169 L2_N13 2.0343862563e+05
R_Dense_2_170_13 L1_N170 L2_N13 2.4718934139e+06
R_Dense_2_171_13 L1_N171 L2_N13 4.1970157564e+05
R_Dense_2_172_13 L1_N172 L2_N13 1.8735721566e+05
R_Dense_2_173_13 L1_N173 L2_N13 5.4090992379e+05
R_Dense_2_174_13 L1_N174 L2_N13 1.7601765433e+05
R_Dense_2_175_13 L1_N175 L2_N13 1.5500068216e+05
R_Dense_2_176_13 L1_N176 L2_N13 8.7686481152e+05
R_Dense_2_177_13 L1_N177 L2_N13 1.2284087140e+05
R_Dense_2_178_13 L1_N178 L2_N13 1.9619295399e+05
R_Dense_2_179_13 L1_N179 L2_N13 1.1044006949e+05
R_Dense_2_180_13 L1_N180 L2_N13 1.3756993609e+05
R_Dense_2_181_13 L1_N181 L2_N13 3.4094185542e+05
R_Dense_2_182_13 L1_N182 L2_N13 3.8889742681e+05
R_Dense_2_183_13 L1_N183 L2_N13 1.0113015499e+05
R_Dense_2_184_13 L1_N184 L2_N13 6.6383677209e+05
R_Dense_2_185_13 L1_N185 L2_N13 2.5588945885e+05
R_Dense_2_186_13 L1_N186 L2_N13 1.0874010409e+05
R_Dense_2_187_13 L1_N187 L2_N13 3.9844035718e+05
R_Dense_2_188_13 L1_N188 L2_N13 2.1000183238e+05
R_Dense_2_189_13 L1_N189 L2_N13 1.0694996717e+05
R_Dense_2_190_13 L1_N190 L2_N13 1.5019434958e+05
R_Dense_2_191_13 L1_N191 L2_N13 1.2664923917e+05
R_Dense_2_192_13 L1_N192 L2_N13 3.3794689656e+05
R_Dense_2_193_13 L1_N193 L2_N13 1.0107244489e+05
R_Dense_2_194_13 L1_N194 L2_N13 2.1882830009e+05
R_Dense_2_195_13 L1_N195 L2_N13 1.0153301899e+05
R_Dense_2_196_13 L1_N196 L2_N13 2.0626124747e+05
R_Dense_2_197_13 L1_N197 L2_N13 1.2277023800e+05
R_Dense_2_198_13 L1_N198 L2_N13 2.7255354905e+06
R_Dense_2_199_13 L1_N199 L2_N13 2.1028649297e+05
R_Dense_2_200_13 L1_N200 L2_N13 4.4521621134e+05
R_Dense_2_201_13 L1_N201 L2_N13 1.6174116039e+05
R_Dense_2_202_13 L1_N202 L2_N13 2.2731411281e+05
R_Dense_2_203_13 L1_N203 L2_N13 2.2439561003e+05
R_Dense_2_204_13 L1_N204 L2_N13 5.1204965454e+05
R_Dense_2_205_13 L1_N205 L2_N13 4.4782119887e+05
R_Dense_2_206_13 L1_N206 L2_N13 1.8423438447e+05
R_Dense_2_207_13 L1_N207 L2_N13 5.4914246541e+05
R_Dense_2_208_13 L1_N208 L2_N13 1.5170412400e+05
R_Dense_2_209_13 L1_N209 L2_N13 1.2777156392e+05
R_Dense_2_210_13 L1_N210 L2_N13 2.1645577969e+06
R_Dense_2_211_13 L1_N211 L2_N13 1.4664879128e+05
R_Dense_2_212_13 L1_N212 L2_N13 3.6213065657e+06
R_Dense_2_213_13 L1_N213 L2_N13 1.6037994786e+05
R_Dense_2_214_13 L1_N214 L2_N13 1.1734266104e+05
R_Dense_2_215_13 L1_N215 L2_N13 1.5879658581e+05
R_Dense_2_216_13 L1_N216 L2_N13 1.6356417103e+05
R_Dense_2_217_13 L1_N217 L2_N13 1.0232075890e+05
R_Dense_2_218_13 L1_N218 L2_N13 1.2774745513e+06
R_Dense_2_219_13 L1_N219 L2_N13 1.1116584200e+05
R_Dense_2_220_13 L1_N220 L2_N13 1.0421387184e+05
R_Dense_2_221_13 L1_N221 L2_N13 1.4066492324e+05
R_Dense_2_222_13 L1_N222 L2_N13 4.4382116311e+05
R_Dense_2_223_13 L1_N223 L2_N13 3.1752559718e+05
R_Dense_2_224_13 L1_N224 L2_N13 1.4241169637e+05
R_Dense_2_225_13 L1_N225 L2_N13 2.9583307751e+05
R_Dense_2_226_13 L1_N226 L2_N13 1.1735615883e+05
R_Dense_2_227_13 L1_N227 L2_N13 1.2277355021e+05
R_Dense_2_228_13 L1_N228 L2_N13 1.4519877747e+05
R_Dense_2_229_13 L1_N229 L2_N13 1.0652165766e+05
R_Dense_2_230_13 L1_N230 L2_N13 2.1407769803e+05
R_Dense_2_231_13 L1_N231 L2_N13 1.1121247676e+05
R_Dense_2_232_13 L1_N232 L2_N13 1.0149655733e+05
R_Dense_2_233_13 L1_N233 L2_N13 1.9525303252e+05
R_Dense_2_234_13 L1_N234 L2_N13 1.2594343104e+05
R_Dense_2_235_13 L1_N235 L2_N13 8.5056819444e+05
R_Dense_2_236_13 L1_N236 L2_N13 1.0080720368e+05
R_Dense_2_237_13 L1_N237 L2_N13 1.2733037649e+05
R_Dense_2_238_13 L1_N238 L2_N13 1.2955656393e+05
R_Dense_2_239_13 L1_N239 L2_N13 2.4289254160e+05
R_Dense_2_240_13 L1_N240 L2_N13 1.7669878322e+05
R_Dense_2_241_13 L1_N241 L2_N13 2.0873362117e+05
R_Dense_2_242_13 L1_N242 L2_N13 1.3850381162e+05
R_Dense_2_243_13 L1_N243 L2_N13 1.4931471073e+05
R_Dense_2_244_13 L1_N244 L2_N13 7.4991001465e+05
R_Dense_2_245_13 L1_N245 L2_N13 1.8305363591e+05
R_Dense_2_246_13 L1_N246 L2_N13 1.1395196604e+05
R_Dense_2_247_13 L1_N247 L2_N13 1.6165552861e+05
R_Dense_2_248_13 L1_N248 L2_N13 1.1903416888e+05
R_Dense_2_249_13 L1_N249 L2_N13 3.7191842415e+05
R_Dense_2_250_13 L1_N250 L2_N13 1.6889317475e+05
R_Dense_2_251_13 L1_N251 L2_N13 3.5877858867e+05
R_Dense_2_252_13 L1_N252 L2_N13 1.2058988457e+06
R_Dense_2_253_13 L1_N253 L2_N13 1.2251834268e+05
R_Dense_2_254_13 L1_N254 L2_N13 6.5758407819e+05
R_Dense_2_255_13 L1_N255 L2_N13 2.3506881862e+05
R_Dense_2_256_13 L1_N256 L2_N13 1.0304611560e+05
R_Dense_2_257_13 L1_N257 L2_N13 1.7279596932e+05
R_Dense_2_258_13 L1_N258 L2_N13 1.0617480611e+05
R_Dense_2_259_13 L1_N259 L2_N13 1.7636641689e+05
R_Dense_2_260_13 L1_N260 L2_N13 1.6780257215e+05
R_Dense_2_261_13 L1_N261 L2_N13 2.5148051758e+05
R_Dense_2_262_13 L1_N262 L2_N13 1.8694197838e+05
R_Dense_2_263_13 L1_N263 L2_N13 2.9790607732e+06
R_Dense_2_264_13 L1_N264 L2_N13 3.2361578929e+05
R_Dense_2_265_13 L1_N265 L2_N13 1.0076832156e+05
R_Dense_2_266_13 L1_N266 L2_N13 1.1093908573e+05
R_Dense_2_267_13 L1_N267 L2_N13 7.1939531550e+05
R_Dense_2_268_13 L1_N268 L2_N13 2.3875613389e+05
R_Dense_2_269_13 L1_N269 L2_N13 1.1851647264e+05
R_Dense_2_270_13 L1_N270 L2_N13 9.0183747764e+05
R_Dense_2_271_13 L1_N271 L2_N13 1.3226045154e+05
R_Dense_2_272_13 L1_N272 L2_N13 2.9896957714e+05
R_Dense_2_273_13 L1_N273 L2_N13 6.8833279430e+05
R_Dense_2_274_13 L1_N274 L2_N13 1.0878691638e+05
R_Dense_2_275_13 L1_N275 L2_N13 1.0229936754e+05
R_Dense_2_276_13 L1_N276 L2_N13 3.6943548172e+06
R_Dense_2_277_13 L1_N277 L2_N13 2.0314609266e+05
R_Dense_2_278_13 L1_N278 L2_N13 1.6079287939e+05
R_Dense_2_279_13 L1_N279 L2_N13 1.0200314764e+05
R_Dense_2_280_13 L1_N280 L2_N13 1.3315389131e+05
R_Dense_2_281_13 L1_N281 L2_N13 1.1152792906e+05
R_Dense_2_282_13 L1_N282 L2_N13 1.5270029571e+05
R_Dense_2_283_13 L1_N283 L2_N13 1.2556519996e+05
R_Dense_2_284_13 L1_N284 L2_N13 2.6094015793e+05
R_Dense_2_285_13 L1_N285 L2_N13 1.1851516515e+05
R_Dense_2_286_13 L1_N286 L2_N13 1.6878400914e+05
R_Dense_2_287_13 L1_N287 L2_N13 1.6330942531e+05
R_Dense_2_288_13 L1_N288 L2_N13 9.7737271688e+05
R_Dense_2_289_13 L1_N289 L2_N13 1.7462401732e+05
R_Dense_2_290_13 L1_N290 L2_N13 1.1273621013e+05
R_Dense_2_291_13 L1_N291 L2_N13 2.2236248383e+05
R_Dense_2_292_13 L1_N292 L2_N13 1.4072356552e+06
R_Dense_2_293_13 L1_N293 L2_N13 1.4387934449e+05
R_Dense_2_294_13 L1_N294 L2_N13 1.1831878406e+05
R_Dense_2_295_13 L1_N295 L2_N13 1.5416809390e+05
R_Dense_2_296_13 L1_N296 L2_N13 1.6046513897e+05
R_Dense_2_297_13 L1_N297 L2_N13 1.4114259176e+05
R_Dense_2_298_13 L1_N298 L2_N13 1.1768070222e+05
R_Dense_2_299_13 L1_N299 L2_N13 1.0345901443e+05
R_Dense_2_300_13 L1_N300 L2_N13 2.2679972237e+05
R_Dense_2_301_13 L1_N301 L2_N13 2.1347587877e+05
R_Dense_2_302_13 L1_N302 L2_N13 7.0938400675e+05
R_Dense_2_303_13 L1_N303 L2_N13 1.3263804843e+05
R_Dense_2_304_13 L1_N304 L2_N13 1.0044592274e+05
R_Dense_2_305_13 L1_N305 L2_N13 1.3005528303e+05
R_Dense_2_306_13 L1_N306 L2_N13 5.6099277882e+05
R_Dense_2_307_13 L1_N307 L2_N13 1.2373129083e+05
R_Dense_2_308_13 L1_N308 L2_N13 1.7690255455e+05
R_Dense_2_309_13 L1_N309 L2_N13 5.0624579398e+06
R_Dense_2_310_13 L1_N310 L2_N13 1.9476175331e+05
R_Dense_2_311_13 L1_N311 L2_N13 1.6149926846e+05
R_Dense_2_312_13 L1_N312 L2_N13 1.2301540352e+05
R_Dense_2_313_13 L1_N313 L2_N13 1.3208166111e+05
R_Dense_2_314_13 L1_N314 L2_N13 1.5661141271e+05
R_Dense_2_315_13 L1_N315 L2_N13 1.3294001336e+06
R_Dense_2_316_13 L1_N316 L2_N13 2.7099490428e+05
R_Dense_2_317_13 L1_N317 L2_N13 1.2063409484e+05
R_Dense_2_318_13 L1_N318 L2_N13 2.2743340978e+05
R_Dense_2_319_13 L1_N319 L2_N13 1.7396982517e+05
R_Dense_2_320_13 L1_N320 L2_N13 1.0655312030e+05
R_Dense_2_321_13 L1_N321 L2_N13 1.4766203690e+05
R_Dense_2_322_13 L1_N322 L2_N13 6.9175413925e+05
R_Dense_2_323_13 L1_N323 L2_N13 1.6959203351e+05
R_Dense_2_324_13 L1_N324 L2_N13 4.5309018613e+05
R_Dense_2_325_13 L1_N325 L2_N13 2.0815775815e+05
R_Dense_2_326_13 L1_N326 L2_N13 2.6592207599e+05
R_Dense_2_327_13 L1_N327 L2_N13 2.3046257516e+05
R_Dense_2_328_13 L1_N328 L2_N13 2.1435146822e+05
R_Dense_2_329_13 L1_N329 L2_N13 2.0788199708e+05
R_Dense_2_330_13 L1_N330 L2_N13 1.0304830448e+05
R_Dense_2_331_13 L1_N331 L2_N13 1.0365847641e+05
R_Dense_2_332_13 L1_N332 L2_N13 2.1285606297e+05
R_Dense_2_333_13 L1_N333 L2_N13 2.7595237918e+05
R_Dense_2_334_13 L1_N334 L2_N13 1.1856569671e+05
R_Dense_2_335_13 L1_N335 L2_N13 1.4537673195e+05
R_Dense_2_336_13 L1_N336 L2_N13 3.9245345289e+05
R_Dense_2_337_13 L1_N337 L2_N13 2.1223063565e+05
*
R_Dense_2_0_14 L1_N0 L2_N14 1.5038333430e+05
R_Dense_2_1_14 L1_N1 L2_N14 7.7334271946e+06
R_Dense_2_2_14 L1_N2 L2_N14 1.1819323134e+05
R_Dense_2_3_14 L1_N3 L2_N14 1.5438503099e+05
R_Dense_2_4_14 L1_N4 L2_N14 1.0362324403e+05
R_Dense_2_5_14 L1_N5 L2_N14 8.1678381034e+05
R_Dense_2_6_14 L1_N6 L2_N14 2.6957740958e+05
R_Dense_2_7_14 L1_N7 L2_N14 4.0540776089e+05
R_Dense_2_8_14 L1_N8 L2_N14 6.6042058800e+05
R_Dense_2_9_14 L1_N9 L2_N14 2.0664741718e+05
R_Dense_2_10_14 L1_N10 L2_N14 1.1677757085e+05
R_Dense_2_11_14 L1_N11 L2_N14 2.0244875365e+05
R_Dense_2_12_14 L1_N12 L2_N14 1.0196328753e+06
R_Dense_2_13_14 L1_N13 L2_N14 3.2455823921e+05
R_Dense_2_14_14 L1_N14 L2_N14 1.0598128455e+06
R_Dense_2_15_14 L1_N15 L2_N14 1.2195504014e+05
R_Dense_2_16_14 L1_N16 L2_N14 1.1919776832e+05
R_Dense_2_17_14 L1_N17 L2_N14 1.8129661826e+05
R_Dense_2_18_14 L1_N18 L2_N14 1.0721177679e+05
R_Dense_2_19_14 L1_N19 L2_N14 1.1216223614e+05
R_Dense_2_20_14 L1_N20 L2_N14 5.3516711065e+05
R_Dense_2_21_14 L1_N21 L2_N14 2.0774183992e+05
R_Dense_2_22_14 L1_N22 L2_N14 3.5382688833e+06
R_Dense_2_23_14 L1_N23 L2_N14 2.2844694721e+05
R_Dense_2_24_14 L1_N24 L2_N14 4.8982930325e+05
R_Dense_2_25_14 L1_N25 L2_N14 1.0010129159e+05
R_Dense_2_26_14 L1_N26 L2_N14 3.7322366460e+05
R_Dense_2_27_14 L1_N27 L2_N14 9.0894679362e+05
R_Dense_2_28_14 L1_N28 L2_N14 8.8206889335e+05
R_Dense_2_29_14 L1_N29 L2_N14 1.0577020331e+05
R_Dense_2_30_14 L1_N30 L2_N14 1.0845398362e+05
R_Dense_2_31_14 L1_N31 L2_N14 2.1090950180e+05
R_Dense_2_32_14 L1_N32 L2_N14 1.5510858412e+05
R_Dense_2_33_14 L1_N33 L2_N14 1.9974022160e+05
R_Dense_2_34_14 L1_N34 L2_N14 1.7783433099e+05
R_Dense_2_35_14 L1_N35 L2_N14 5.7301865596e+05
R_Dense_2_36_14 L1_N36 L2_N14 1.4694187139e+05
R_Dense_2_37_14 L1_N37 L2_N14 1.7063930392e+05
R_Dense_2_38_14 L1_N38 L2_N14 6.0854269606e+05
R_Dense_2_39_14 L1_N39 L2_N14 2.2768001677e+05
R_Dense_2_40_14 L1_N40 L2_N14 1.7383447811e+05
R_Dense_2_41_14 L1_N41 L2_N14 1.7994932656e+05
R_Dense_2_42_14 L1_N42 L2_N14 1.2087699661e+05
R_Dense_2_43_14 L1_N43 L2_N14 2.3266843665e+05
R_Dense_2_44_14 L1_N44 L2_N14 2.0019614379e+05
R_Dense_2_45_14 L1_N45 L2_N14 1.1316743945e+05
R_Dense_2_46_14 L1_N46 L2_N14 1.3532709875e+05
R_Dense_2_47_14 L1_N47 L2_N14 1.0966117915e+05
R_Dense_2_48_14 L1_N48 L2_N14 5.0240767570e+05
R_Dense_2_49_14 L1_N49 L2_N14 1.9378031512e+05
R_Dense_2_50_14 L1_N50 L2_N14 1.2198215101e+05
R_Dense_2_51_14 L1_N51 L2_N14 1.2337322035e+05
R_Dense_2_52_14 L1_N52 L2_N14 1.3888237706e+06
R_Dense_2_53_14 L1_N53 L2_N14 1.7898003954e+05
R_Dense_2_54_14 L1_N54 L2_N14 3.0830837461e+06
R_Dense_2_55_14 L1_N55 L2_N14 1.7191083488e+05
R_Dense_2_56_14 L1_N56 L2_N14 4.2367438241e+05
R_Dense_2_57_14 L1_N57 L2_N14 2.2166683285e+05
R_Dense_2_58_14 L1_N58 L2_N14 1.7590913207e+05
R_Dense_2_59_14 L1_N59 L2_N14 1.7425963686e+05
R_Dense_2_60_14 L1_N60 L2_N14 1.0050364099e+06
R_Dense_2_61_14 L1_N61 L2_N14 1.7343539949e+05
R_Dense_2_62_14 L1_N62 L2_N14 1.2794312558e+05
R_Dense_2_63_14 L1_N63 L2_N14 2.7678528464e+05
R_Dense_2_64_14 L1_N64 L2_N14 5.1022178525e+05
R_Dense_2_65_14 L1_N65 L2_N14 1.9518575128e+05
R_Dense_2_66_14 L1_N66 L2_N14 1.3852580807e+06
R_Dense_2_67_14 L1_N67 L2_N14 8.8742478839e+05
R_Dense_2_68_14 L1_N68 L2_N14 8.1880989423e+05
R_Dense_2_69_14 L1_N69 L2_N14 1.3299837742e+05
R_Dense_2_70_14 L1_N70 L2_N14 2.1483472033e+05
R_Dense_2_71_14 L1_N71 L2_N14 4.6296038807e+05
R_Dense_2_72_14 L1_N72 L2_N14 1.2208810965e+05
R_Dense_2_73_14 L1_N73 L2_N14 5.2047945737e+05
R_Dense_2_74_14 L1_N74 L2_N14 2.6509359906e+05
R_Dense_2_75_14 L1_N75 L2_N14 1.1562135138e+05
R_Dense_2_76_14 L1_N76 L2_N14 2.3648818387e+05
R_Dense_2_77_14 L1_N77 L2_N14 1.0222154450e+05
R_Dense_2_78_14 L1_N78 L2_N14 2.0063701633e+05
R_Dense_2_79_14 L1_N79 L2_N14 1.8717793142e+05
R_Dense_2_80_14 L1_N80 L2_N14 3.1078609046e+05
R_Dense_2_81_14 L1_N81 L2_N14 1.3733433154e+06
R_Dense_2_82_14 L1_N82 L2_N14 6.3034615172e+05
R_Dense_2_83_14 L1_N83 L2_N14 1.5838091785e+05
R_Dense_2_84_14 L1_N84 L2_N14 1.9964299661e+05
R_Dense_2_85_14 L1_N85 L2_N14 1.2491559758e+05
R_Dense_2_86_14 L1_N86 L2_N14 2.6585358547e+05
R_Dense_2_87_14 L1_N87 L2_N14 4.9660840006e+05
R_Dense_2_88_14 L1_N88 L2_N14 2.4779077414e+05
R_Dense_2_89_14 L1_N89 L2_N14 1.3932280786e+05
R_Dense_2_90_14 L1_N90 L2_N14 1.5420132353e+05
R_Dense_2_91_14 L1_N91 L2_N14 1.1837549470e+05
R_Dense_2_92_14 L1_N92 L2_N14 2.1692983688e+05
R_Dense_2_93_14 L1_N93 L2_N14 1.3929062759e+05
R_Dense_2_94_14 L1_N94 L2_N14 1.8082832314e+05
R_Dense_2_95_14 L1_N95 L2_N14 1.0635401717e+05
R_Dense_2_96_14 L1_N96 L2_N14 1.6401172909e+05
R_Dense_2_97_14 L1_N97 L2_N14 1.8233317754e+05
R_Dense_2_98_14 L1_N98 L2_N14 2.4696197665e+05
R_Dense_2_99_14 L1_N99 L2_N14 1.3307590448e+05
R_Dense_2_100_14 L1_N100 L2_N14 1.0714617757e+05
R_Dense_2_101_14 L1_N101 L2_N14 2.4840822744e+05
R_Dense_2_102_14 L1_N102 L2_N14 1.0843145311e+06
R_Dense_2_103_14 L1_N103 L2_N14 2.0782722397e+05
R_Dense_2_104_14 L1_N104 L2_N14 2.3711276334e+05
R_Dense_2_105_14 L1_N105 L2_N14 1.6274356550e+06
R_Dense_2_106_14 L1_N106 L2_N14 2.2499142103e+05
R_Dense_2_107_14 L1_N107 L2_N14 9.5196703102e+05
R_Dense_2_108_14 L1_N108 L2_N14 1.4492856826e+05
R_Dense_2_109_14 L1_N109 L2_N14 3.3978813302e+06
R_Dense_2_110_14 L1_N110 L2_N14 4.7920713466e+05
R_Dense_2_111_14 L1_N111 L2_N14 1.5519860891e+05
R_Dense_2_112_14 L1_N112 L2_N14 3.0060761686e+05
R_Dense_2_113_14 L1_N113 L2_N14 4.1435334771e+05
R_Dense_2_114_14 L1_N114 L2_N14 3.9656655116e+05
R_Dense_2_115_14 L1_N115 L2_N14 8.3263711318e+05
R_Dense_2_116_14 L1_N116 L2_N14 1.2839023426e+05
R_Dense_2_117_14 L1_N117 L2_N14 1.6732480714e+05
R_Dense_2_118_14 L1_N118 L2_N14 8.5827979036e+05
R_Dense_2_119_14 L1_N119 L2_N14 1.2782513177e+05
R_Dense_2_120_14 L1_N120 L2_N14 3.5793580076e+05
R_Dense_2_121_14 L1_N121 L2_N14 1.1714931455e+06
R_Dense_2_122_14 L1_N122 L2_N14 1.5306832482e+05
R_Dense_2_123_14 L1_N123 L2_N14 1.6561275047e+05
R_Dense_2_124_14 L1_N124 L2_N14 7.0761645006e+05
R_Dense_2_125_14 L1_N125 L2_N14 1.9374014468e+05
R_Dense_2_126_14 L1_N126 L2_N14 6.8307354067e+05
R_Dense_2_127_14 L1_N127 L2_N14 6.1747610241e+05
R_Dense_2_128_14 L1_N128 L2_N14 1.2478150884e+05
R_Dense_2_129_14 L1_N129 L2_N14 1.9174862853e+05
R_Dense_2_130_14 L1_N130 L2_N14 2.5756988307e+05
R_Dense_2_131_14 L1_N131 L2_N14 1.4340036743e+05
R_Dense_2_132_14 L1_N132 L2_N14 1.0076974478e+05
R_Dense_2_133_14 L1_N133 L2_N14 2.7708987507e+05
R_Dense_2_134_14 L1_N134 L2_N14 1.0820500590e+05
R_Dense_2_135_14 L1_N135 L2_N14 2.9746994094e+05
R_Dense_2_136_14 L1_N136 L2_N14 1.7910709964e+05
R_Dense_2_137_14 L1_N137 L2_N14 2.2270708849e+05
R_Dense_2_138_14 L1_N138 L2_N14 1.8517593749e+06
R_Dense_2_139_14 L1_N139 L2_N14 1.1973433592e+05
R_Dense_2_140_14 L1_N140 L2_N14 2.4719540807e+05
R_Dense_2_141_14 L1_N141 L2_N14 2.0135190111e+05
R_Dense_2_142_14 L1_N142 L2_N14 1.3432517643e+05
R_Dense_2_143_14 L1_N143 L2_N14 1.9854031356e+05
R_Dense_2_144_14 L1_N144 L2_N14 1.0182955449e+05
R_Dense_2_145_14 L1_N145 L2_N14 1.9744373162e+05
R_Dense_2_146_14 L1_N146 L2_N14 3.2787709682e+05
R_Dense_2_147_14 L1_N147 L2_N14 1.1753860269e+06
R_Dense_2_148_14 L1_N148 L2_N14 1.7110184619e+05
R_Dense_2_149_14 L1_N149 L2_N14 2.4836393976e+05
R_Dense_2_150_14 L1_N150 L2_N14 3.0798882430e+05
R_Dense_2_151_14 L1_N151 L2_N14 2.1188902062e+05
R_Dense_2_152_14 L1_N152 L2_N14 3.0461360772e+06
R_Dense_2_153_14 L1_N153 L2_N14 1.1615982605e+05
R_Dense_2_154_14 L1_N154 L2_N14 1.8319487270e+05
R_Dense_2_155_14 L1_N155 L2_N14 2.0684345729e+05
R_Dense_2_156_14 L1_N156 L2_N14 1.0729553927e+05
R_Dense_2_157_14 L1_N157 L2_N14 6.9920366321e+05
R_Dense_2_158_14 L1_N158 L2_N14 2.0367451243e+05
R_Dense_2_159_14 L1_N159 L2_N14 2.6056912175e+06
R_Dense_2_160_14 L1_N160 L2_N14 1.5011777028e+05
R_Dense_2_161_14 L1_N161 L2_N14 1.2889971886e+06
R_Dense_2_162_14 L1_N162 L2_N14 1.0570783036e+05
R_Dense_2_163_14 L1_N163 L2_N14 1.4731813539e+05
R_Dense_2_164_14 L1_N164 L2_N14 1.4600424581e+05
R_Dense_2_165_14 L1_N165 L2_N14 1.3104395676e+05
R_Dense_2_166_14 L1_N166 L2_N14 1.2086201947e+06
R_Dense_2_167_14 L1_N167 L2_N14 1.1588819775e+06
R_Dense_2_168_14 L1_N168 L2_N14 1.6013998963e+05
R_Dense_2_169_14 L1_N169 L2_N14 1.1301154595e+05
R_Dense_2_170_14 L1_N170 L2_N14 3.0105334402e+05
R_Dense_2_171_14 L1_N171 L2_N14 2.2256020527e+05
R_Dense_2_172_14 L1_N172 L2_N14 1.1069618255e+05
R_Dense_2_173_14 L1_N173 L2_N14 1.9074652914e+06
R_Dense_2_174_14 L1_N174 L2_N14 4.4836930423e+05
R_Dense_2_175_14 L1_N175 L2_N14 1.1142654559e+05
R_Dense_2_176_14 L1_N176 L2_N14 1.7271937811e+05
R_Dense_2_177_14 L1_N177 L2_N14 5.4057472446e+05
R_Dense_2_178_14 L1_N178 L2_N14 4.5602545814e+05
R_Dense_2_179_14 L1_N179 L2_N14 1.0955793951e+05
R_Dense_2_180_14 L1_N180 L2_N14 2.4631223701e+05
R_Dense_2_181_14 L1_N181 L2_N14 1.0111462172e+05
R_Dense_2_182_14 L1_N182 L2_N14 1.2900647037e+05
R_Dense_2_183_14 L1_N183 L2_N14 1.0482187240e+05
R_Dense_2_184_14 L1_N184 L2_N14 3.3378554036e+05
R_Dense_2_185_14 L1_N185 L2_N14 1.3767899135e+05
R_Dense_2_186_14 L1_N186 L2_N14 1.0004544051e+05
R_Dense_2_187_14 L1_N187 L2_N14 1.5145835625e+06
R_Dense_2_188_14 L1_N188 L2_N14 3.5774162503e+05
R_Dense_2_189_14 L1_N189 L2_N14 1.1029703099e+05
R_Dense_2_190_14 L1_N190 L2_N14 6.6675256898e+05
R_Dense_2_191_14 L1_N191 L2_N14 1.6063766133e+05
R_Dense_2_192_14 L1_N192 L2_N14 2.3283003793e+05
R_Dense_2_193_14 L1_N193 L2_N14 2.6839112823e+05
R_Dense_2_194_14 L1_N194 L2_N14 1.1425758875e+06
R_Dense_2_195_14 L1_N195 L2_N14 1.2634065027e+05
R_Dense_2_196_14 L1_N196 L2_N14 1.4237827575e+05
R_Dense_2_197_14 L1_N197 L2_N14 1.1253162465e+05
R_Dense_2_198_14 L1_N198 L2_N14 8.1517628635e+05
R_Dense_2_199_14 L1_N199 L2_N14 1.0355074938e+05
R_Dense_2_200_14 L1_N200 L2_N14 1.1743038660e+05
R_Dense_2_201_14 L1_N201 L2_N14 1.1453399537e+05
R_Dense_2_202_14 L1_N202 L2_N14 1.3913198708e+05
R_Dense_2_203_14 L1_N203 L2_N14 3.2578428388e+06
R_Dense_2_204_14 L1_N204 L2_N14 3.0516112711e+05
R_Dense_2_205_14 L1_N205 L2_N14 4.1031877570e+05
R_Dense_2_206_14 L1_N206 L2_N14 1.1330081901e+05
R_Dense_2_207_14 L1_N207 L2_N14 1.1883959282e+05
R_Dense_2_208_14 L1_N208 L2_N14 1.2395375669e+05
R_Dense_2_209_14 L1_N209 L2_N14 1.8109746467e+05
R_Dense_2_210_14 L1_N210 L2_N14 1.3422166078e+06
R_Dense_2_211_14 L1_N211 L2_N14 1.5329272809e+05
R_Dense_2_212_14 L1_N212 L2_N14 1.4162857650e+05
R_Dense_2_213_14 L1_N213 L2_N14 7.0296897293e+05
R_Dense_2_214_14 L1_N214 L2_N14 1.2364288334e+05
R_Dense_2_215_14 L1_N215 L2_N14 1.0732320675e+05
R_Dense_2_216_14 L1_N216 L2_N14 2.3246847678e+05
R_Dense_2_217_14 L1_N217 L2_N14 1.3400969006e+05
R_Dense_2_218_14 L1_N218 L2_N14 2.4751687110e+05
R_Dense_2_219_14 L1_N219 L2_N14 1.1351751589e+05
R_Dense_2_220_14 L1_N220 L2_N14 1.0477343584e+06
R_Dense_2_221_14 L1_N221 L2_N14 1.0428404201e+05
R_Dense_2_222_14 L1_N222 L2_N14 2.6177674194e+05
R_Dense_2_223_14 L1_N223 L2_N14 2.9788357325e+06
R_Dense_2_224_14 L1_N224 L2_N14 5.3589918222e+05
R_Dense_2_225_14 L1_N225 L2_N14 1.3526359976e+05
R_Dense_2_226_14 L1_N226 L2_N14 1.1662443948e+05
R_Dense_2_227_14 L1_N227 L2_N14 7.0566141449e+05
R_Dense_2_228_14 L1_N228 L2_N14 2.9606291524e+05
R_Dense_2_229_14 L1_N229 L2_N14 1.3571971667e+05
R_Dense_2_230_14 L1_N230 L2_N14 4.5033205374e+05
R_Dense_2_231_14 L1_N231 L2_N14 4.7182724553e+05
R_Dense_2_232_14 L1_N232 L2_N14 5.5555988736e+05
R_Dense_2_233_14 L1_N233 L2_N14 4.1197409574e+05
R_Dense_2_234_14 L1_N234 L2_N14 1.9396305910e+05
R_Dense_2_235_14 L1_N235 L2_N14 5.7956299900e+05
R_Dense_2_236_14 L1_N236 L2_N14 4.0577275252e+05
R_Dense_2_237_14 L1_N237 L2_N14 5.3327383095e+05
R_Dense_2_238_14 L1_N238 L2_N14 1.7049135375e+05
R_Dense_2_239_14 L1_N239 L2_N14 3.1166959181e+05
R_Dense_2_240_14 L1_N240 L2_N14 1.3073237848e+05
R_Dense_2_241_14 L1_N241 L2_N14 4.9895791594e+05
R_Dense_2_242_14 L1_N242 L2_N14 1.9853683014e+05
R_Dense_2_243_14 L1_N243 L2_N14 1.4791121638e+05
R_Dense_2_244_14 L1_N244 L2_N14 3.1419902281e+05
R_Dense_2_245_14 L1_N245 L2_N14 6.0562751427e+05
R_Dense_2_246_14 L1_N246 L2_N14 1.8598838595e+05
R_Dense_2_247_14 L1_N247 L2_N14 1.0859518988e+05
R_Dense_2_248_14 L1_N248 L2_N14 5.4264179130e+05
R_Dense_2_249_14 L1_N249 L2_N14 3.9794223353e+05
R_Dense_2_250_14 L1_N250 L2_N14 1.3054287095e+05
R_Dense_2_251_14 L1_N251 L2_N14 1.2520743891e+05
R_Dense_2_252_14 L1_N252 L2_N14 1.1777715187e+05
R_Dense_2_253_14 L1_N253 L2_N14 1.4778795834e+05
R_Dense_2_254_14 L1_N254 L2_N14 4.6257008574e+05
R_Dense_2_255_14 L1_N255 L2_N14 1.0240097112e+05
R_Dense_2_256_14 L1_N256 L2_N14 2.3639114097e+05
R_Dense_2_257_14 L1_N257 L2_N14 2.5393948824e+05
R_Dense_2_258_14 L1_N258 L2_N14 1.1220614143e+05
R_Dense_2_259_14 L1_N259 L2_N14 3.7171569955e+05
R_Dense_2_260_14 L1_N260 L2_N14 1.6987149643e+06
R_Dense_2_261_14 L1_N261 L2_N14 1.2323279390e+05
R_Dense_2_262_14 L1_N262 L2_N14 1.0322537263e+05
R_Dense_2_263_14 L1_N263 L2_N14 1.0444698480e+05
R_Dense_2_264_14 L1_N264 L2_N14 1.2495293441e+05
R_Dense_2_265_14 L1_N265 L2_N14 1.1853036854e+05
R_Dense_2_266_14 L1_N266 L2_N14 1.2215421560e+05
R_Dense_2_267_14 L1_N267 L2_N14 3.1342177655e+05
R_Dense_2_268_14 L1_N268 L2_N14 1.3489792822e+05
R_Dense_2_269_14 L1_N269 L2_N14 1.3009858822e+05
R_Dense_2_270_14 L1_N270 L2_N14 3.1542733691e+05
R_Dense_2_271_14 L1_N271 L2_N14 1.3337666395e+05
R_Dense_2_272_14 L1_N272 L2_N14 5.9494564697e+05
R_Dense_2_273_14 L1_N273 L2_N14 1.7753986591e+05
R_Dense_2_274_14 L1_N274 L2_N14 4.0907532266e+05
R_Dense_2_275_14 L1_N275 L2_N14 1.7032791881e+05
R_Dense_2_276_14 L1_N276 L2_N14 3.9454695506e+05
R_Dense_2_277_14 L1_N277 L2_N14 1.0734080559e+05
R_Dense_2_278_14 L1_N278 L2_N14 6.1241637905e+05
R_Dense_2_279_14 L1_N279 L2_N14 1.0927319386e+06
R_Dense_2_280_14 L1_N280 L2_N14 1.1525087936e+05
R_Dense_2_281_14 L1_N281 L2_N14 1.1506993719e+05
R_Dense_2_282_14 L1_N282 L2_N14 3.2507730789e+05
R_Dense_2_283_14 L1_N283 L2_N14 2.0374994124e+05
R_Dense_2_284_14 L1_N284 L2_N14 2.1533663773e+05
R_Dense_2_285_14 L1_N285 L2_N14 8.9403767183e+05
R_Dense_2_286_14 L1_N286 L2_N14 1.4260766252e+06
R_Dense_2_287_14 L1_N287 L2_N14 5.4528850811e+05
R_Dense_2_288_14 L1_N288 L2_N14 1.4832194772e+05
R_Dense_2_289_14 L1_N289 L2_N14 1.9571962343e+05
R_Dense_2_290_14 L1_N290 L2_N14 1.7680107110e+05
R_Dense_2_291_14 L1_N291 L2_N14 2.2892217906e+06
R_Dense_2_292_14 L1_N292 L2_N14 1.2342837364e+06
R_Dense_2_293_14 L1_N293 L2_N14 1.6680772916e+05
R_Dense_2_294_14 L1_N294 L2_N14 1.7814002721e+05
R_Dense_2_295_14 L1_N295 L2_N14 1.7480256276e+05
R_Dense_2_296_14 L1_N296 L2_N14 1.2739992497e+05
R_Dense_2_297_14 L1_N297 L2_N14 3.0348951997e+05
R_Dense_2_298_14 L1_N298 L2_N14 1.1262753653e+05
R_Dense_2_299_14 L1_N299 L2_N14 2.8898121288e+05
R_Dense_2_300_14 L1_N300 L2_N14 1.0178225607e+05
R_Dense_2_301_14 L1_N301 L2_N14 1.4470217174e+05
R_Dense_2_302_14 L1_N302 L2_N14 2.1696589035e+05
R_Dense_2_303_14 L1_N303 L2_N14 8.4315786398e+05
R_Dense_2_304_14 L1_N304 L2_N14 2.9539356913e+05
R_Dense_2_305_14 L1_N305 L2_N14 9.2941284434e+05
R_Dense_2_306_14 L1_N306 L2_N14 1.7382968274e+05
R_Dense_2_307_14 L1_N307 L2_N14 2.6079661259e+05
R_Dense_2_308_14 L1_N308 L2_N14 3.0796186402e+05
R_Dense_2_309_14 L1_N309 L2_N14 1.9658450527e+05
R_Dense_2_310_14 L1_N310 L2_N14 1.4539248097e+05
R_Dense_2_311_14 L1_N311 L2_N14 1.2233330805e+05
R_Dense_2_312_14 L1_N312 L2_N14 5.3103981023e+05
R_Dense_2_313_14 L1_N313 L2_N14 1.0304712851e+05
R_Dense_2_314_14 L1_N314 L2_N14 1.1692621648e+05
R_Dense_2_315_14 L1_N315 L2_N14 1.9760971109e+05
R_Dense_2_316_14 L1_N316 L2_N14 1.2907943688e+05
R_Dense_2_317_14 L1_N317 L2_N14 2.2494733040e+06
R_Dense_2_318_14 L1_N318 L2_N14 4.5753430047e+06
R_Dense_2_319_14 L1_N319 L2_N14 1.2678240490e+05
R_Dense_2_320_14 L1_N320 L2_N14 1.6660010221e+06
R_Dense_2_321_14 L1_N321 L2_N14 2.6440052994e+05
R_Dense_2_322_14 L1_N322 L2_N14 2.3939486647e+05
R_Dense_2_323_14 L1_N323 L2_N14 1.1630098243e+05
R_Dense_2_324_14 L1_N324 L2_N14 4.4515377874e+06
R_Dense_2_325_14 L1_N325 L2_N14 1.5218025945e+05
R_Dense_2_326_14 L1_N326 L2_N14 1.2369978900e+05
R_Dense_2_327_14 L1_N327 L2_N14 7.2640840284e+05
R_Dense_2_328_14 L1_N328 L2_N14 1.1029575839e+05
R_Dense_2_329_14 L1_N329 L2_N14 3.3173001289e+05
R_Dense_2_330_14 L1_N330 L2_N14 1.5469393120e+05
R_Dense_2_331_14 L1_N331 L2_N14 1.0662316535e+05
R_Dense_2_332_14 L1_N332 L2_N14 1.2981923917e+06
R_Dense_2_333_14 L1_N333 L2_N14 1.1595441503e+05
R_Dense_2_334_14 L1_N334 L2_N14 2.5924544211e+06
R_Dense_2_335_14 L1_N335 L2_N14 2.0888320031e+05
R_Dense_2_336_14 L1_N336 L2_N14 1.0525629635e+05
R_Dense_2_337_14 L1_N337 L2_N14 1.1903329996e+05
*
R_Dense_2_0_15 L1_N0 L2_N15 8.3979260694e+05
R_Dense_2_1_15 L1_N1 L2_N15 3.3842957921e+05
R_Dense_2_2_15 L1_N2 L2_N15 2.0792851523e+06
R_Dense_2_3_15 L1_N3 L2_N15 1.3457650352e+06
R_Dense_2_4_15 L1_N4 L2_N15 1.0521479024e+05
R_Dense_2_5_15 L1_N5 L2_N15 2.0225235393e+05
R_Dense_2_6_15 L1_N6 L2_N15 1.7654824641e+05
R_Dense_2_7_15 L1_N7 L2_N15 3.9190315950e+05
R_Dense_2_8_15 L1_N8 L2_N15 1.6014534099e+06
R_Dense_2_9_15 L1_N9 L2_N15 1.3065707958e+05
R_Dense_2_10_15 L1_N10 L2_N15 2.4998620890e+05
R_Dense_2_11_15 L1_N11 L2_N15 2.7869748570e+05
R_Dense_2_12_15 L1_N12 L2_N15 2.4927640066e+06
R_Dense_2_13_15 L1_N13 L2_N15 7.7903356484e+05
R_Dense_2_14_15 L1_N14 L2_N15 1.1938391784e+05
R_Dense_2_15_15 L1_N15 L2_N15 1.2363717703e+06
R_Dense_2_16_15 L1_N16 L2_N15 2.2499949395e+06
R_Dense_2_17_15 L1_N17 L2_N15 5.3997595005e+05
R_Dense_2_18_15 L1_N18 L2_N15 1.5650495426e+05
R_Dense_2_19_15 L1_N19 L2_N15 1.6251025558e+05
R_Dense_2_20_15 L1_N20 L2_N15 1.0382979945e+05
R_Dense_2_21_15 L1_N21 L2_N15 1.0580975059e+05
R_Dense_2_22_15 L1_N22 L2_N15 1.6474800295e+05
R_Dense_2_23_15 L1_N23 L2_N15 2.5093963594e+05
R_Dense_2_24_15 L1_N24 L2_N15 2.4703483923e+05
R_Dense_2_25_15 L1_N25 L2_N15 1.2572040231e+05
R_Dense_2_26_15 L1_N26 L2_N15 1.1844194622e+05
R_Dense_2_27_15 L1_N27 L2_N15 1.8219735339e+05
R_Dense_2_28_15 L1_N28 L2_N15 1.2689525555e+05
R_Dense_2_29_15 L1_N29 L2_N15 1.6175779602e+05
R_Dense_2_30_15 L1_N30 L2_N15 1.8524423804e+05
R_Dense_2_31_15 L1_N31 L2_N15 2.1349483868e+05
R_Dense_2_32_15 L1_N32 L2_N15 8.1455804747e+05
R_Dense_2_33_15 L1_N33 L2_N15 1.6435842846e+05
R_Dense_2_34_15 L1_N34 L2_N15 2.3685590836e+05
R_Dense_2_35_15 L1_N35 L2_N15 1.2018265798e+05
R_Dense_2_36_15 L1_N36 L2_N15 1.0789323981e+05
R_Dense_2_37_15 L1_N37 L2_N15 1.8120621171e+05
R_Dense_2_38_15 L1_N38 L2_N15 2.8148615560e+05
R_Dense_2_39_15 L1_N39 L2_N15 1.2965609007e+05
R_Dense_2_40_15 L1_N40 L2_N15 5.6196364347e+05
R_Dense_2_41_15 L1_N41 L2_N15 5.3578447420e+06
R_Dense_2_42_15 L1_N42 L2_N15 2.2206138011e+05
R_Dense_2_43_15 L1_N43 L2_N15 1.4250531806e+05
R_Dense_2_44_15 L1_N44 L2_N15 1.1326576851e+05
R_Dense_2_45_15 L1_N45 L2_N15 5.1607987694e+05
R_Dense_2_46_15 L1_N46 L2_N15 2.2570828880e+05
R_Dense_2_47_15 L1_N47 L2_N15 2.5775051642e+05
R_Dense_2_48_15 L1_N48 L2_N15 1.0647225474e+05
R_Dense_2_49_15 L1_N49 L2_N15 1.2346695355e+05
R_Dense_2_50_15 L1_N50 L2_N15 3.4934271662e+05
R_Dense_2_51_15 L1_N51 L2_N15 2.8892629820e+05
R_Dense_2_52_15 L1_N52 L2_N15 1.1901716307e+05
R_Dense_2_53_15 L1_N53 L2_N15 1.7245674065e+05
R_Dense_2_54_15 L1_N54 L2_N15 1.4647664542e+05
R_Dense_2_55_15 L1_N55 L2_N15 1.0673117362e+05
R_Dense_2_56_15 L1_N56 L2_N15 2.2396195613e+05
R_Dense_2_57_15 L1_N57 L2_N15 1.2547472508e+05
R_Dense_2_58_15 L1_N58 L2_N15 2.5514637754e+05
R_Dense_2_59_15 L1_N59 L2_N15 2.3657655550e+05
R_Dense_2_60_15 L1_N60 L2_N15 1.7777055568e+05
R_Dense_2_61_15 L1_N61 L2_N15 3.2150103927e+05
R_Dense_2_62_15 L1_N62 L2_N15 1.2371382088e+05
R_Dense_2_63_15 L1_N63 L2_N15 4.5442797617e+05
R_Dense_2_64_15 L1_N64 L2_N15 1.1652578324e+05
R_Dense_2_65_15 L1_N65 L2_N15 1.3055100967e+05
R_Dense_2_66_15 L1_N66 L2_N15 1.1714008828e+05
R_Dense_2_67_15 L1_N67 L2_N15 1.5367015078e+06
R_Dense_2_68_15 L1_N68 L2_N15 3.3645031267e+05
R_Dense_2_69_15 L1_N69 L2_N15 2.5820279250e+05
R_Dense_2_70_15 L1_N70 L2_N15 2.2297230525e+05
R_Dense_2_71_15 L1_N71 L2_N15 1.1959357214e+05
R_Dense_2_72_15 L1_N72 L2_N15 2.0909488543e+05
R_Dense_2_73_15 L1_N73 L2_N15 1.3233042308e+05
R_Dense_2_74_15 L1_N74 L2_N15 1.0296142854e+05
R_Dense_2_75_15 L1_N75 L2_N15 1.2139518612e+05
R_Dense_2_76_15 L1_N76 L2_N15 2.4509303739e+06
R_Dense_2_77_15 L1_N77 L2_N15 1.7682929184e+05
R_Dense_2_78_15 L1_N78 L2_N15 2.9344998042e+05
R_Dense_2_79_15 L1_N79 L2_N15 2.8514442879e+05
R_Dense_2_80_15 L1_N80 L2_N15 3.9104978498e+05
R_Dense_2_81_15 L1_N81 L2_N15 1.7269872486e+05
R_Dense_2_82_15 L1_N82 L2_N15 1.2861124841e+05
R_Dense_2_83_15 L1_N83 L2_N15 2.7834177051e+05
R_Dense_2_84_15 L1_N84 L2_N15 1.1618965558e+05
R_Dense_2_85_15 L1_N85 L2_N15 2.9180429894e+05
R_Dense_2_86_15 L1_N86 L2_N15 1.0536593116e+06
R_Dense_2_87_15 L1_N87 L2_N15 1.0444106269e+05
R_Dense_2_88_15 L1_N88 L2_N15 7.7091801891e+05
R_Dense_2_89_15 L1_N89 L2_N15 2.9563154446e+06
R_Dense_2_90_15 L1_N90 L2_N15 7.2403607707e+05
R_Dense_2_91_15 L1_N91 L2_N15 1.0319031585e+05
R_Dense_2_92_15 L1_N92 L2_N15 2.4586170565e+06
R_Dense_2_93_15 L1_N93 L2_N15 1.8909158550e+05
R_Dense_2_94_15 L1_N94 L2_N15 1.3501141396e+05
R_Dense_2_95_15 L1_N95 L2_N15 1.1205135605e+05
R_Dense_2_96_15 L1_N96 L2_N15 2.3181459937e+05
R_Dense_2_97_15 L1_N97 L2_N15 1.3083628564e+06
R_Dense_2_98_15 L1_N98 L2_N15 4.0212038388e+05
R_Dense_2_99_15 L1_N99 L2_N15 7.0622816189e+05
R_Dense_2_100_15 L1_N100 L2_N15 1.4273060378e+05
R_Dense_2_101_15 L1_N101 L2_N15 2.1137732954e+05
R_Dense_2_102_15 L1_N102 L2_N15 3.4232732974e+05
R_Dense_2_103_15 L1_N103 L2_N15 2.8700771604e+05
R_Dense_2_104_15 L1_N104 L2_N15 1.3548237553e+05
R_Dense_2_105_15 L1_N105 L2_N15 1.4471585644e+05
R_Dense_2_106_15 L1_N106 L2_N15 1.3264676608e+05
R_Dense_2_107_15 L1_N107 L2_N15 4.1301797556e+05
R_Dense_2_108_15 L1_N108 L2_N15 1.5264289986e+05
R_Dense_2_109_15 L1_N109 L2_N15 6.1314938731e+05
R_Dense_2_110_15 L1_N110 L2_N15 1.5397496414e+05
R_Dense_2_111_15 L1_N111 L2_N15 1.0782475827e+05
R_Dense_2_112_15 L1_N112 L2_N15 1.0145552970e+05
R_Dense_2_113_15 L1_N113 L2_N15 1.1279297119e+05
R_Dense_2_114_15 L1_N114 L2_N15 4.3108222618e+05
R_Dense_2_115_15 L1_N115 L2_N15 2.0946434313e+05
R_Dense_2_116_15 L1_N116 L2_N15 1.6236811378e+05
R_Dense_2_117_15 L1_N117 L2_N15 2.6803607668e+05
R_Dense_2_118_15 L1_N118 L2_N15 4.9123841852e+05
R_Dense_2_119_15 L1_N119 L2_N15 2.0128173672e+05
R_Dense_2_120_15 L1_N120 L2_N15 2.4486129838e+06
R_Dense_2_121_15 L1_N121 L2_N15 1.1336876391e+05
R_Dense_2_122_15 L1_N122 L2_N15 1.0846615994e+05
R_Dense_2_123_15 L1_N123 L2_N15 4.7485372245e+05
R_Dense_2_124_15 L1_N124 L2_N15 6.1808749576e+05
R_Dense_2_125_15 L1_N125 L2_N15 1.2419339376e+05
R_Dense_2_126_15 L1_N126 L2_N15 1.2247317244e+05
R_Dense_2_127_15 L1_N127 L2_N15 1.3278667879e+06
R_Dense_2_128_15 L1_N128 L2_N15 1.5594755460e+05
R_Dense_2_129_15 L1_N129 L2_N15 1.0241321940e+05
R_Dense_2_130_15 L1_N130 L2_N15 5.7276857525e+05
R_Dense_2_131_15 L1_N131 L2_N15 1.9539995116e+05
R_Dense_2_132_15 L1_N132 L2_N15 3.0844631222e+05
R_Dense_2_133_15 L1_N133 L2_N15 2.9478882567e+06
R_Dense_2_134_15 L1_N134 L2_N15 8.1704397153e+06
R_Dense_2_135_15 L1_N135 L2_N15 3.2816632394e+05
R_Dense_2_136_15 L1_N136 L2_N15 1.1268155075e+05
R_Dense_2_137_15 L1_N137 L2_N15 5.4849810495e+05
R_Dense_2_138_15 L1_N138 L2_N15 3.8165648862e+05
R_Dense_2_139_15 L1_N139 L2_N15 1.4294959521e+05
R_Dense_2_140_15 L1_N140 L2_N15 6.3603404648e+05
R_Dense_2_141_15 L1_N141 L2_N15 7.2057072430e+05
R_Dense_2_142_15 L1_N142 L2_N15 7.7961840438e+05
R_Dense_2_143_15 L1_N143 L2_N15 7.5364452033e+05
R_Dense_2_144_15 L1_N144 L2_N15 7.2674748930e+05
R_Dense_2_145_15 L1_N145 L2_N15 1.1665523188e+05
R_Dense_2_146_15 L1_N146 L2_N15 1.1134770704e+05
R_Dense_2_147_15 L1_N147 L2_N15 2.1481872150e+05
R_Dense_2_148_15 L1_N148 L2_N15 1.0509988905e+06
R_Dense_2_149_15 L1_N149 L2_N15 1.7775988955e+05
R_Dense_2_150_15 L1_N150 L2_N15 1.0492615433e+05
R_Dense_2_151_15 L1_N151 L2_N15 1.7098466369e+05
R_Dense_2_152_15 L1_N152 L2_N15 1.3891496889e+05
R_Dense_2_153_15 L1_N153 L2_N15 1.2034962112e+05
R_Dense_2_154_15 L1_N154 L2_N15 1.6959351484e+06
R_Dense_2_155_15 L1_N155 L2_N15 3.7008702916e+05
R_Dense_2_156_15 L1_N156 L2_N15 1.4099530086e+05
R_Dense_2_157_15 L1_N157 L2_N15 1.3921789644e+05
R_Dense_2_158_15 L1_N158 L2_N15 4.7443779220e+05
R_Dense_2_159_15 L1_N159 L2_N15 1.5038569694e+05
R_Dense_2_160_15 L1_N160 L2_N15 1.3309228597e+05
R_Dense_2_161_15 L1_N161 L2_N15 3.4260341100e+05
R_Dense_2_162_15 L1_N162 L2_N15 2.1754192710e+05
R_Dense_2_163_15 L1_N163 L2_N15 2.4302737148e+05
R_Dense_2_164_15 L1_N164 L2_N15 1.1284712408e+05
R_Dense_2_165_15 L1_N165 L2_N15 5.7296790099e+06
R_Dense_2_166_15 L1_N166 L2_N15 1.6812900508e+05
R_Dense_2_167_15 L1_N167 L2_N15 1.0397852202e+05
R_Dense_2_168_15 L1_N168 L2_N15 1.1043099604e+05
R_Dense_2_169_15 L1_N169 L2_N15 1.1356051232e+05
R_Dense_2_170_15 L1_N170 L2_N15 2.5584658661e+05
R_Dense_2_171_15 L1_N171 L2_N15 1.8322705143e+05
R_Dense_2_172_15 L1_N172 L2_N15 1.3086859332e+05
R_Dense_2_173_15 L1_N173 L2_N15 3.9051258883e+05
R_Dense_2_174_15 L1_N174 L2_N15 8.7192159989e+05
R_Dense_2_175_15 L1_N175 L2_N15 2.8379218519e+05
R_Dense_2_176_15 L1_N176 L2_N15 1.3875786423e+05
R_Dense_2_177_15 L1_N177 L2_N15 2.1623939648e+06
R_Dense_2_178_15 L1_N178 L2_N15 6.4884278599e+05
R_Dense_2_179_15 L1_N179 L2_N15 2.2492163354e+05
R_Dense_2_180_15 L1_N180 L2_N15 7.5084262914e+05
R_Dense_2_181_15 L1_N181 L2_N15 1.5017743721e+05
R_Dense_2_182_15 L1_N182 L2_N15 2.2968684430e+05
R_Dense_2_183_15 L1_N183 L2_N15 2.2368639840e+06
R_Dense_2_184_15 L1_N184 L2_N15 1.5788137115e+05
R_Dense_2_185_15 L1_N185 L2_N15 2.4509688703e+05
R_Dense_2_186_15 L1_N186 L2_N15 1.3847466931e+05
R_Dense_2_187_15 L1_N187 L2_N15 1.2576767867e+05
R_Dense_2_188_15 L1_N188 L2_N15 1.5422851339e+05
R_Dense_2_189_15 L1_N189 L2_N15 1.8305592413e+05
R_Dense_2_190_15 L1_N190 L2_N15 2.1783683610e+05
R_Dense_2_191_15 L1_N191 L2_N15 1.3945889220e+05
R_Dense_2_192_15 L1_N192 L2_N15 1.2037410847e+05
R_Dense_2_193_15 L1_N193 L2_N15 2.5935941346e+05
R_Dense_2_194_15 L1_N194 L2_N15 3.5165282274e+05
R_Dense_2_195_15 L1_N195 L2_N15 3.4525030659e+05
R_Dense_2_196_15 L1_N196 L2_N15 1.3367665500e+05
R_Dense_2_197_15 L1_N197 L2_N15 1.7129819160e+05
R_Dense_2_198_15 L1_N198 L2_N15 3.0862749139e+05
R_Dense_2_199_15 L1_N199 L2_N15 2.8498800180e+05
R_Dense_2_200_15 L1_N200 L2_N15 7.3924744230e+05
R_Dense_2_201_15 L1_N201 L2_N15 1.6532790236e+05
R_Dense_2_202_15 L1_N202 L2_N15 4.7018121250e+06
R_Dense_2_203_15 L1_N203 L2_N15 2.5764588025e+05
R_Dense_2_204_15 L1_N204 L2_N15 2.6380454374e+05
R_Dense_2_205_15 L1_N205 L2_N15 9.4142163437e+05
R_Dense_2_206_15 L1_N206 L2_N15 5.0213485810e+05
R_Dense_2_207_15 L1_N207 L2_N15 1.5879708015e+05
R_Dense_2_208_15 L1_N208 L2_N15 1.6710922711e+05
R_Dense_2_209_15 L1_N209 L2_N15 1.7953420429e+05
R_Dense_2_210_15 L1_N210 L2_N15 3.1762825246e+05
R_Dense_2_211_15 L1_N211 L2_N15 1.5152527709e+05
R_Dense_2_212_15 L1_N212 L2_N15 1.3411659600e+05
R_Dense_2_213_15 L1_N213 L2_N15 1.3929905056e+05
R_Dense_2_214_15 L1_N214 L2_N15 2.5964427681e+05
R_Dense_2_215_15 L1_N215 L2_N15 1.4167858822e+05
R_Dense_2_216_15 L1_N216 L2_N15 1.9405947625e+05
R_Dense_2_217_15 L1_N217 L2_N15 1.7376179464e+05
R_Dense_2_218_15 L1_N218 L2_N15 1.5838922284e+05
R_Dense_2_219_15 L1_N219 L2_N15 1.0542086819e+05
R_Dense_2_220_15 L1_N220 L2_N15 3.6768952198e+05
R_Dense_2_221_15 L1_N221 L2_N15 1.1297524062e+05
R_Dense_2_222_15 L1_N222 L2_N15 1.0547239462e+05
R_Dense_2_223_15 L1_N223 L2_N15 3.3071077244e+05
R_Dense_2_224_15 L1_N224 L2_N15 1.7257090176e+05
R_Dense_2_225_15 L1_N225 L2_N15 1.0705355226e+05
R_Dense_2_226_15 L1_N226 L2_N15 5.0562095165e+05
R_Dense_2_227_15 L1_N227 L2_N15 3.0481720549e+05
R_Dense_2_228_15 L1_N228 L2_N15 2.7522418741e+05
R_Dense_2_229_15 L1_N229 L2_N15 1.4521998074e+05
R_Dense_2_230_15 L1_N230 L2_N15 4.9942952105e+05
R_Dense_2_231_15 L1_N231 L2_N15 3.4445243287e+06
R_Dense_2_232_15 L1_N232 L2_N15 1.1542202964e+05
R_Dense_2_233_15 L1_N233 L2_N15 6.4696024140e+05
R_Dense_2_234_15 L1_N234 L2_N15 1.3852863706e+05
R_Dense_2_235_15 L1_N235 L2_N15 1.2287295552e+05
R_Dense_2_236_15 L1_N236 L2_N15 1.8946412255e+05
R_Dense_2_237_15 L1_N237 L2_N15 2.7285430051e+05
R_Dense_2_238_15 L1_N238 L2_N15 2.9865243294e+05
R_Dense_2_239_15 L1_N239 L2_N15 3.7852120411e+05
R_Dense_2_240_15 L1_N240 L2_N15 2.8385012209e+06
R_Dense_2_241_15 L1_N241 L2_N15 1.0289563914e+05
R_Dense_2_242_15 L1_N242 L2_N15 1.0931703090e+05
R_Dense_2_243_15 L1_N243 L2_N15 1.5468688648e+05
R_Dense_2_244_15 L1_N244 L2_N15 1.2126693646e+05
R_Dense_2_245_15 L1_N245 L2_N15 1.3719798907e+05
R_Dense_2_246_15 L1_N246 L2_N15 1.3579253277e+05
R_Dense_2_247_15 L1_N247 L2_N15 2.4748657856e+05
R_Dense_2_248_15 L1_N248 L2_N15 1.2205537760e+05
R_Dense_2_249_15 L1_N249 L2_N15 2.3145757129e+05
R_Dense_2_250_15 L1_N250 L2_N15 1.0020488787e+05
R_Dense_2_251_15 L1_N251 L2_N15 4.7681086401e+05
R_Dense_2_252_15 L1_N252 L2_N15 2.1441262419e+05
R_Dense_2_253_15 L1_N253 L2_N15 2.9034822784e+05
R_Dense_2_254_15 L1_N254 L2_N15 1.9808504087e+05
R_Dense_2_255_15 L1_N255 L2_N15 1.5114519247e+05
R_Dense_2_256_15 L1_N256 L2_N15 1.1043958176e+05
R_Dense_2_257_15 L1_N257 L2_N15 2.9948478897e+05
R_Dense_2_258_15 L1_N258 L2_N15 1.0472465231e+05
R_Dense_2_259_15 L1_N259 L2_N15 1.4566159531e+05
R_Dense_2_260_15 L1_N260 L2_N15 2.0643358220e+05
R_Dense_2_261_15 L1_N261 L2_N15 1.0180945924e+05
R_Dense_2_262_15 L1_N262 L2_N15 3.5227365753e+05
R_Dense_2_263_15 L1_N263 L2_N15 2.8161672867e+05
R_Dense_2_264_15 L1_N264 L2_N15 1.6674280408e+05
R_Dense_2_265_15 L1_N265 L2_N15 1.8346965791e+05
R_Dense_2_266_15 L1_N266 L2_N15 5.1739331950e+05
R_Dense_2_267_15 L1_N267 L2_N15 1.3731876485e+05
R_Dense_2_268_15 L1_N268 L2_N15 1.1372268093e+05
R_Dense_2_269_15 L1_N269 L2_N15 1.2784034806e+05
R_Dense_2_270_15 L1_N270 L2_N15 1.6901827160e+05
R_Dense_2_271_15 L1_N271 L2_N15 1.1911285020e+06
R_Dense_2_272_15 L1_N272 L2_N15 1.8541456847e+05
R_Dense_2_273_15 L1_N273 L2_N15 1.0380159396e+06
R_Dense_2_274_15 L1_N274 L2_N15 1.3434154738e+05
R_Dense_2_275_15 L1_N275 L2_N15 1.2859021756e+05
R_Dense_2_276_15 L1_N276 L2_N15 2.6336586047e+05
R_Dense_2_277_15 L1_N277 L2_N15 1.4329233068e+05
R_Dense_2_278_15 L1_N278 L2_N15 1.3697346187e+05
R_Dense_2_279_15 L1_N279 L2_N15 2.0576796814e+05
R_Dense_2_280_15 L1_N280 L2_N15 1.4562331594e+05
R_Dense_2_281_15 L1_N281 L2_N15 2.1712493377e+05
R_Dense_2_282_15 L1_N282 L2_N15 4.1353922757e+05
R_Dense_2_283_15 L1_N283 L2_N15 2.2580885813e+05
R_Dense_2_284_15 L1_N284 L2_N15 2.4132778130e+05
R_Dense_2_285_15 L1_N285 L2_N15 1.5016733079e+05
R_Dense_2_286_15 L1_N286 L2_N15 5.8114776254e+05
R_Dense_2_287_15 L1_N287 L2_N15 1.2284790444e+05
R_Dense_2_288_15 L1_N288 L2_N15 1.2272285239e+06
R_Dense_2_289_15 L1_N289 L2_N15 5.1790521161e+05
R_Dense_2_290_15 L1_N290 L2_N15 5.7830543707e+05
R_Dense_2_291_15 L1_N291 L2_N15 1.3005411672e+05
R_Dense_2_292_15 L1_N292 L2_N15 1.5685325097e+05
R_Dense_2_293_15 L1_N293 L2_N15 1.2739783823e+05
R_Dense_2_294_15 L1_N294 L2_N15 1.6517855970e+05
R_Dense_2_295_15 L1_N295 L2_N15 1.0347119823e+05
R_Dense_2_296_15 L1_N296 L2_N15 1.2278210850e+05
R_Dense_2_297_15 L1_N297 L2_N15 2.4492970195e+05
R_Dense_2_298_15 L1_N298 L2_N15 1.2989080432e+05
R_Dense_2_299_15 L1_N299 L2_N15 2.1157866408e+05
R_Dense_2_300_15 L1_N300 L2_N15 1.4445400220e+06
R_Dense_2_301_15 L1_N301 L2_N15 1.0983820479e+05
R_Dense_2_302_15 L1_N302 L2_N15 1.3472184426e+05
R_Dense_2_303_15 L1_N303 L2_N15 1.3064307252e+05
R_Dense_2_304_15 L1_N304 L2_N15 1.9034485668e+06
R_Dense_2_305_15 L1_N305 L2_N15 1.7097402958e+05
R_Dense_2_306_15 L1_N306 L2_N15 2.8011351840e+05
R_Dense_2_307_15 L1_N307 L2_N15 1.7882974985e+05
R_Dense_2_308_15 L1_N308 L2_N15 2.8117849085e+05
R_Dense_2_309_15 L1_N309 L2_N15 1.8651619064e+05
R_Dense_2_310_15 L1_N310 L2_N15 2.2776755978e+05
R_Dense_2_311_15 L1_N311 L2_N15 3.4555542181e+05
R_Dense_2_312_15 L1_N312 L2_N15 2.8595755785e+05
R_Dense_2_313_15 L1_N313 L2_N15 3.3636017049e+05
R_Dense_2_314_15 L1_N314 L2_N15 2.8247171347e+06
R_Dense_2_315_15 L1_N315 L2_N15 6.6258306932e+05
R_Dense_2_316_15 L1_N316 L2_N15 1.3698548323e+05
R_Dense_2_317_15 L1_N317 L2_N15 1.5401581336e+05
R_Dense_2_318_15 L1_N318 L2_N15 1.8248249412e+05
R_Dense_2_319_15 L1_N319 L2_N15 1.1286166823e+05
R_Dense_2_320_15 L1_N320 L2_N15 1.9775472804e+05
R_Dense_2_321_15 L1_N321 L2_N15 5.7076775745e+05
R_Dense_2_322_15 L1_N322 L2_N15 2.7153671899e+05
R_Dense_2_323_15 L1_N323 L2_N15 7.7017407555e+05
R_Dense_2_324_15 L1_N324 L2_N15 8.3477115094e+05
R_Dense_2_325_15 L1_N325 L2_N15 1.4638154960e+05
R_Dense_2_326_15 L1_N326 L2_N15 1.0140418740e+05
R_Dense_2_327_15 L1_N327 L2_N15 2.7314199804e+05
R_Dense_2_328_15 L1_N328 L2_N15 2.8291301513e+05
R_Dense_2_329_15 L1_N329 L2_N15 2.1249262150e+05
R_Dense_2_330_15 L1_N330 L2_N15 1.4658543493e+05
R_Dense_2_331_15 L1_N331 L2_N15 2.1607295367e+05
R_Dense_2_332_15 L1_N332 L2_N15 1.7890631946e+05
R_Dense_2_333_15 L1_N333 L2_N15 2.5980766120e+06
R_Dense_2_334_15 L1_N334 L2_N15 1.3676678668e+05
R_Dense_2_335_15 L1_N335 L2_N15 1.6252272693e+05
R_Dense_2_336_15 L1_N336 L2_N15 9.9659633109e+05
R_Dense_2_337_15 L1_N337 L2_N15 4.9446071779e+05
*
R_Dense_2_0_16 L1_N0 L2_N16 1.6548314216e+05
R_Dense_2_1_16 L1_N1 L2_N16 1.0724313483e+05
R_Dense_2_2_16 L1_N2 L2_N16 1.7171306902e+05
R_Dense_2_3_16 L1_N3 L2_N16 2.1873035249e+05
R_Dense_2_4_16 L1_N4 L2_N16 1.4149219826e+06
R_Dense_2_5_16 L1_N5 L2_N16 1.4491455575e+05
R_Dense_2_6_16 L1_N6 L2_N16 1.7596177345e+05
R_Dense_2_7_16 L1_N7 L2_N16 4.3261947245e+05
R_Dense_2_8_16 L1_N8 L2_N16 2.3968633701e+05
R_Dense_2_9_16 L1_N9 L2_N16 2.2341152955e+05
R_Dense_2_10_16 L1_N10 L2_N16 3.8300129501e+05
R_Dense_2_11_16 L1_N11 L2_N16 1.3719133748e+05
R_Dense_2_12_16 L1_N12 L2_N16 5.5250426554e+05
R_Dense_2_13_16 L1_N13 L2_N16 2.0990140548e+05
R_Dense_2_14_16 L1_N14 L2_N16 1.6579766477e+05
R_Dense_2_15_16 L1_N15 L2_N16 7.2646903568e+06
R_Dense_2_16_16 L1_N16 L2_N16 1.6388838837e+05
R_Dense_2_17_16 L1_N17 L2_N16 2.9226967439e+05
R_Dense_2_18_16 L1_N18 L2_N16 1.0240852494e+05
R_Dense_2_19_16 L1_N19 L2_N16 2.5055967504e+05
R_Dense_2_20_16 L1_N20 L2_N16 1.8413352973e+05
R_Dense_2_21_16 L1_N21 L2_N16 1.3180886883e+05
R_Dense_2_22_16 L1_N22 L2_N16 2.5303688072e+05
R_Dense_2_23_16 L1_N23 L2_N16 3.7513339385e+05
R_Dense_2_24_16 L1_N24 L2_N16 2.0525620778e+05
R_Dense_2_25_16 L1_N25 L2_N16 4.0695457520e+05
R_Dense_2_26_16 L1_N26 L2_N16 1.1573184876e+05
R_Dense_2_27_16 L1_N27 L2_N16 4.1628421823e+05
R_Dense_2_28_16 L1_N28 L2_N16 1.6980672020e+05
R_Dense_2_29_16 L1_N29 L2_N16 1.0056246055e+05
R_Dense_2_30_16 L1_N30 L2_N16 2.4561298749e+05
R_Dense_2_31_16 L1_N31 L2_N16 1.0029245787e+05
R_Dense_2_32_16 L1_N32 L2_N16 1.0863061700e+06
R_Dense_2_33_16 L1_N33 L2_N16 1.0745602687e+05
R_Dense_2_34_16 L1_N34 L2_N16 1.5493080637e+05
R_Dense_2_35_16 L1_N35 L2_N16 1.1248038179e+05
R_Dense_2_36_16 L1_N36 L2_N16 1.0827591268e+06
R_Dense_2_37_16 L1_N37 L2_N16 1.0849535802e+05
R_Dense_2_38_16 L1_N38 L2_N16 1.3572493937e+05
R_Dense_2_39_16 L1_N39 L2_N16 1.0415402109e+06
R_Dense_2_40_16 L1_N40 L2_N16 1.0223923697e+05
R_Dense_2_41_16 L1_N41 L2_N16 2.4202188376e+05
R_Dense_2_42_16 L1_N42 L2_N16 1.0043884182e+06
R_Dense_2_43_16 L1_N43 L2_N16 1.0587912492e+05
R_Dense_2_44_16 L1_N44 L2_N16 1.0105892606e+05
R_Dense_2_45_16 L1_N45 L2_N16 1.4177655083e+05
R_Dense_2_46_16 L1_N46 L2_N16 1.8516258480e+05
R_Dense_2_47_16 L1_N47 L2_N16 1.5436847892e+05
R_Dense_2_48_16 L1_N48 L2_N16 1.8635467857e+05
R_Dense_2_49_16 L1_N49 L2_N16 1.8768433404e+05
R_Dense_2_50_16 L1_N50 L2_N16 1.2573806243e+05
R_Dense_2_51_16 L1_N51 L2_N16 9.3965258366e+05
R_Dense_2_52_16 L1_N52 L2_N16 1.7998732785e+05
R_Dense_2_53_16 L1_N53 L2_N16 1.4384387578e+05
R_Dense_2_54_16 L1_N54 L2_N16 2.6417930159e+05
R_Dense_2_55_16 L1_N55 L2_N16 2.0730901723e+05
R_Dense_2_56_16 L1_N56 L2_N16 2.6976720395e+05
R_Dense_2_57_16 L1_N57 L2_N16 2.3771878386e+05
R_Dense_2_58_16 L1_N58 L2_N16 1.0606901626e+06
R_Dense_2_59_16 L1_N59 L2_N16 2.1596994719e+05
R_Dense_2_60_16 L1_N60 L2_N16 3.9199720765e+05
R_Dense_2_61_16 L1_N61 L2_N16 1.0690124095e+05
R_Dense_2_62_16 L1_N62 L2_N16 1.2497593510e+05
R_Dense_2_63_16 L1_N63 L2_N16 2.0403661332e+05
R_Dense_2_64_16 L1_N64 L2_N16 1.4900540009e+05
R_Dense_2_65_16 L1_N65 L2_N16 1.7159090771e+05
R_Dense_2_66_16 L1_N66 L2_N16 1.8878162317e+05
R_Dense_2_67_16 L1_N67 L2_N16 1.4559332248e+05
R_Dense_2_68_16 L1_N68 L2_N16 1.2409974396e+05
R_Dense_2_69_16 L1_N69 L2_N16 1.5079767844e+05
R_Dense_2_70_16 L1_N70 L2_N16 4.3494356032e+05
R_Dense_2_71_16 L1_N71 L2_N16 2.3154692044e+05
R_Dense_2_72_16 L1_N72 L2_N16 2.6440696771e+05
R_Dense_2_73_16 L1_N73 L2_N16 1.4948292439e+05
R_Dense_2_74_16 L1_N74 L2_N16 1.6852490769e+05
R_Dense_2_75_16 L1_N75 L2_N16 9.5676183792e+05
R_Dense_2_76_16 L1_N76 L2_N16 3.9336822007e+05
R_Dense_2_77_16 L1_N77 L2_N16 7.4113076458e+05
R_Dense_2_78_16 L1_N78 L2_N16 1.9418364301e+05
R_Dense_2_79_16 L1_N79 L2_N16 1.0118321135e+05
R_Dense_2_80_16 L1_N80 L2_N16 3.6404331944e+05
R_Dense_2_81_16 L1_N81 L2_N16 1.7744989162e+05
R_Dense_2_82_16 L1_N82 L2_N16 2.0723562929e+05
R_Dense_2_83_16 L1_N83 L2_N16 1.4924971576e+05
R_Dense_2_84_16 L1_N84 L2_N16 1.7714650567e+05
R_Dense_2_85_16 L1_N85 L2_N16 1.3374336324e+06
R_Dense_2_86_16 L1_N86 L2_N16 1.1013938898e+05
R_Dense_2_87_16 L1_N87 L2_N16 2.1399877180e+05
R_Dense_2_88_16 L1_N88 L2_N16 1.4111994752e+05
R_Dense_2_89_16 L1_N89 L2_N16 1.7137338575e+05
R_Dense_2_90_16 L1_N90 L2_N16 2.9464919551e+05
R_Dense_2_91_16 L1_N91 L2_N16 1.4760629880e+05
R_Dense_2_92_16 L1_N92 L2_N16 1.0483678012e+05
R_Dense_2_93_16 L1_N93 L2_N16 1.1068655847e+05
R_Dense_2_94_16 L1_N94 L2_N16 1.0299210544e+05
R_Dense_2_95_16 L1_N95 L2_N16 2.9552764100e+05
R_Dense_2_96_16 L1_N96 L2_N16 3.8057709176e+06
R_Dense_2_97_16 L1_N97 L2_N16 2.2903731753e+05
R_Dense_2_98_16 L1_N98 L2_N16 8.5927014311e+05
R_Dense_2_99_16 L1_N99 L2_N16 1.5504004292e+05
R_Dense_2_100_16 L1_N100 L2_N16 3.5072067186e+05
R_Dense_2_101_16 L1_N101 L2_N16 1.9267281134e+05
R_Dense_2_102_16 L1_N102 L2_N16 1.4675280777e+05
R_Dense_2_103_16 L1_N103 L2_N16 1.3372047528e+05
R_Dense_2_104_16 L1_N104 L2_N16 6.5995625502e+05
R_Dense_2_105_16 L1_N105 L2_N16 6.2635192224e+05
R_Dense_2_106_16 L1_N106 L2_N16 1.8658480145e+05
R_Dense_2_107_16 L1_N107 L2_N16 1.3720986517e+05
R_Dense_2_108_16 L1_N108 L2_N16 2.0235743455e+05
R_Dense_2_109_16 L1_N109 L2_N16 1.8405578180e+05
R_Dense_2_110_16 L1_N110 L2_N16 1.5447926070e+05
R_Dense_2_111_16 L1_N111 L2_N16 2.8434948948e+05
R_Dense_2_112_16 L1_N112 L2_N16 1.1721862139e+05
R_Dense_2_113_16 L1_N113 L2_N16 1.4498127431e+05
R_Dense_2_114_16 L1_N114 L2_N16 1.1953834920e+05
R_Dense_2_115_16 L1_N115 L2_N16 1.9478590377e+05
R_Dense_2_116_16 L1_N116 L2_N16 1.4150515620e+06
R_Dense_2_117_16 L1_N117 L2_N16 1.2393634613e+06
R_Dense_2_118_16 L1_N118 L2_N16 1.2351429919e+05
R_Dense_2_119_16 L1_N119 L2_N16 3.9735233234e+05
R_Dense_2_120_16 L1_N120 L2_N16 1.3476844873e+05
R_Dense_2_121_16 L1_N121 L2_N16 3.1275144976e+05
R_Dense_2_122_16 L1_N122 L2_N16 1.7977938561e+05
R_Dense_2_123_16 L1_N123 L2_N16 2.4122982036e+05
R_Dense_2_124_16 L1_N124 L2_N16 1.0765522085e+06
R_Dense_2_125_16 L1_N125 L2_N16 4.0779113418e+05
R_Dense_2_126_16 L1_N126 L2_N16 2.1626130248e+06
R_Dense_2_127_16 L1_N127 L2_N16 6.8751115715e+05
R_Dense_2_128_16 L1_N128 L2_N16 1.3159029591e+05
R_Dense_2_129_16 L1_N129 L2_N16 1.3982162071e+05
R_Dense_2_130_16 L1_N130 L2_N16 1.4585183279e+05
R_Dense_2_131_16 L1_N131 L2_N16 1.4744721499e+05
R_Dense_2_132_16 L1_N132 L2_N16 2.1323277052e+05
R_Dense_2_133_16 L1_N133 L2_N16 3.4931383946e+05
R_Dense_2_134_16 L1_N134 L2_N16 2.2555744565e+05
R_Dense_2_135_16 L1_N135 L2_N16 4.8820846806e+05
R_Dense_2_136_16 L1_N136 L2_N16 1.6591839067e+05
R_Dense_2_137_16 L1_N137 L2_N16 1.7761012184e+05
R_Dense_2_138_16 L1_N138 L2_N16 6.3745493365e+05
R_Dense_2_139_16 L1_N139 L2_N16 1.0901178713e+05
R_Dense_2_140_16 L1_N140 L2_N16 5.3499940617e+05
R_Dense_2_141_16 L1_N141 L2_N16 6.8675900840e+05
R_Dense_2_142_16 L1_N142 L2_N16 1.2365866198e+05
R_Dense_2_143_16 L1_N143 L2_N16 3.2684615407e+05
R_Dense_2_144_16 L1_N144 L2_N16 3.3261782498e+05
R_Dense_2_145_16 L1_N145 L2_N16 1.0940179482e+05
R_Dense_2_146_16 L1_N146 L2_N16 4.3178885322e+05
R_Dense_2_147_16 L1_N147 L2_N16 1.4770757184e+05
R_Dense_2_148_16 L1_N148 L2_N16 1.5005985061e+05
R_Dense_2_149_16 L1_N149 L2_N16 1.4320572478e+05
R_Dense_2_150_16 L1_N150 L2_N16 1.4427221572e+05
R_Dense_2_151_16 L1_N151 L2_N16 1.0456676941e+05
R_Dense_2_152_16 L1_N152 L2_N16 1.3933383704e+05
R_Dense_2_153_16 L1_N153 L2_N16 3.2400610289e+05
R_Dense_2_154_16 L1_N154 L2_N16 1.0843508559e+05
R_Dense_2_155_16 L1_N155 L2_N16 3.5318718510e+05
R_Dense_2_156_16 L1_N156 L2_N16 1.1218302202e+05
R_Dense_2_157_16 L1_N157 L2_N16 1.9695748160e+05
R_Dense_2_158_16 L1_N158 L2_N16 1.2783117140e+05
R_Dense_2_159_16 L1_N159 L2_N16 2.8198082509e+05
R_Dense_2_160_16 L1_N160 L2_N16 1.1925775832e+05
R_Dense_2_161_16 L1_N161 L2_N16 2.2089519552e+05
R_Dense_2_162_16 L1_N162 L2_N16 6.3917599939e+05
R_Dense_2_163_16 L1_N163 L2_N16 2.3512799847e+05
R_Dense_2_164_16 L1_N164 L2_N16 2.0147711849e+05
R_Dense_2_165_16 L1_N165 L2_N16 2.6554304652e+05
R_Dense_2_166_16 L1_N166 L2_N16 1.0924383843e+05
R_Dense_2_167_16 L1_N167 L2_N16 2.5058318064e+05
R_Dense_2_168_16 L1_N168 L2_N16 4.8315732636e+05
R_Dense_2_169_16 L1_N169 L2_N16 3.3061910942e+05
R_Dense_2_170_16 L1_N170 L2_N16 2.1519504913e+05
R_Dense_2_171_16 L1_N171 L2_N16 4.1642360457e+05
R_Dense_2_172_16 L1_N172 L2_N16 3.8645305997e+05
R_Dense_2_173_16 L1_N173 L2_N16 1.0700242951e+05
R_Dense_2_174_16 L1_N174 L2_N16 1.6146418776e+05
R_Dense_2_175_16 L1_N175 L2_N16 2.5939652037e+05
R_Dense_2_176_16 L1_N176 L2_N16 4.7477068636e+05
R_Dense_2_177_16 L1_N177 L2_N16 3.5345403443e+05
R_Dense_2_178_16 L1_N178 L2_N16 3.7138053448e+05
R_Dense_2_179_16 L1_N179 L2_N16 1.1152720539e+05
R_Dense_2_180_16 L1_N180 L2_N16 1.4798699179e+05
R_Dense_2_181_16 L1_N181 L2_N16 1.9763021215e+05
R_Dense_2_182_16 L1_N182 L2_N16 2.4370069555e+05
R_Dense_2_183_16 L1_N183 L2_N16 6.6279265438e+05
R_Dense_2_184_16 L1_N184 L2_N16 7.0650284457e+05
R_Dense_2_185_16 L1_N185 L2_N16 1.5000337410e+05
R_Dense_2_186_16 L1_N186 L2_N16 2.1628509900e+05
R_Dense_2_187_16 L1_N187 L2_N16 4.1413829404e+05
R_Dense_2_188_16 L1_N188 L2_N16 1.0183119493e+05
R_Dense_2_189_16 L1_N189 L2_N16 4.0544167229e+05
R_Dense_2_190_16 L1_N190 L2_N16 1.5843527462e+06
R_Dense_2_191_16 L1_N191 L2_N16 7.0978502180e+05
R_Dense_2_192_16 L1_N192 L2_N16 1.1295152728e+05
R_Dense_2_193_16 L1_N193 L2_N16 6.3221870807e+05
R_Dense_2_194_16 L1_N194 L2_N16 3.1207071022e+05
R_Dense_2_195_16 L1_N195 L2_N16 1.1120361697e+05
R_Dense_2_196_16 L1_N196 L2_N16 4.7713583092e+05
R_Dense_2_197_16 L1_N197 L2_N16 1.0571036067e+05
R_Dense_2_198_16 L1_N198 L2_N16 7.6338041722e+05
R_Dense_2_199_16 L1_N199 L2_N16 1.7248763169e+05
R_Dense_2_200_16 L1_N200 L2_N16 1.8433222819e+05
R_Dense_2_201_16 L1_N201 L2_N16 2.1036879427e+05
R_Dense_2_202_16 L1_N202 L2_N16 3.0290898940e+05
R_Dense_2_203_16 L1_N203 L2_N16 1.5998328762e+06
R_Dense_2_204_16 L1_N204 L2_N16 1.3516426557e+05
R_Dense_2_205_16 L1_N205 L2_N16 4.8246592909e+06
R_Dense_2_206_16 L1_N206 L2_N16 4.8548632909e+05
R_Dense_2_207_16 L1_N207 L2_N16 3.1638595322e+05
R_Dense_2_208_16 L1_N208 L2_N16 2.3526211519e+05
R_Dense_2_209_16 L1_N209 L2_N16 1.6052980259e+05
R_Dense_2_210_16 L1_N210 L2_N16 1.4846302968e+05
R_Dense_2_211_16 L1_N211 L2_N16 1.4279686713e+05
R_Dense_2_212_16 L1_N212 L2_N16 2.1111320231e+05
R_Dense_2_213_16 L1_N213 L2_N16 1.2557318972e+05
R_Dense_2_214_16 L1_N214 L2_N16 1.3872559458e+05
R_Dense_2_215_16 L1_N215 L2_N16 2.4209572740e+05
R_Dense_2_216_16 L1_N216 L2_N16 1.2338556682e+05
R_Dense_2_217_16 L1_N217 L2_N16 1.0750054734e+05
R_Dense_2_218_16 L1_N218 L2_N16 1.0674833427e+05
R_Dense_2_219_16 L1_N219 L2_N16 3.6908687610e+05
R_Dense_2_220_16 L1_N220 L2_N16 7.1160818528e+05
R_Dense_2_221_16 L1_N221 L2_N16 1.1001066676e+05
R_Dense_2_222_16 L1_N222 L2_N16 1.0587749714e+05
R_Dense_2_223_16 L1_N223 L2_N16 3.1575194304e+05
R_Dense_2_224_16 L1_N224 L2_N16 7.4470540941e+06
R_Dense_2_225_16 L1_N225 L2_N16 1.5030499648e+06
R_Dense_2_226_16 L1_N226 L2_N16 9.5221991317e+05
R_Dense_2_227_16 L1_N227 L2_N16 1.8052043733e+06
R_Dense_2_228_16 L1_N228 L2_N16 1.6057211963e+05
R_Dense_2_229_16 L1_N229 L2_N16 1.0583218985e+05
R_Dense_2_230_16 L1_N230 L2_N16 3.5706525884e+05
R_Dense_2_231_16 L1_N231 L2_N16 4.5899056591e+05
R_Dense_2_232_16 L1_N232 L2_N16 5.8100496078e+05
R_Dense_2_233_16 L1_N233 L2_N16 1.0055999741e+05
R_Dense_2_234_16 L1_N234 L2_N16 1.0350758976e+05
R_Dense_2_235_16 L1_N235 L2_N16 1.6559011820e+05
R_Dense_2_236_16 L1_N236 L2_N16 1.7954881421e+05
R_Dense_2_237_16 L1_N237 L2_N16 1.5722074633e+05
R_Dense_2_238_16 L1_N238 L2_N16 1.5762270686e+05
R_Dense_2_239_16 L1_N239 L2_N16 2.3132186477e+05
R_Dense_2_240_16 L1_N240 L2_N16 3.2669815637e+05
R_Dense_2_241_16 L1_N241 L2_N16 1.7795190372e+05
R_Dense_2_242_16 L1_N242 L2_N16 1.4910170047e+05
R_Dense_2_243_16 L1_N243 L2_N16 1.4999696905e+05
R_Dense_2_244_16 L1_N244 L2_N16 1.0876377873e+05
R_Dense_2_245_16 L1_N245 L2_N16 1.0493743199e+06
R_Dense_2_246_16 L1_N246 L2_N16 2.5736802094e+05
R_Dense_2_247_16 L1_N247 L2_N16 1.1546235299e+05
R_Dense_2_248_16 L1_N248 L2_N16 1.0788983885e+05
R_Dense_2_249_16 L1_N249 L2_N16 1.8858397578e+05
R_Dense_2_250_16 L1_N250 L2_N16 4.2822987978e+05
R_Dense_2_251_16 L1_N251 L2_N16 2.4697863277e+05
R_Dense_2_252_16 L1_N252 L2_N16 5.6880476014e+05
R_Dense_2_253_16 L1_N253 L2_N16 1.0662786357e+05
R_Dense_2_254_16 L1_N254 L2_N16 1.1380851096e+05
R_Dense_2_255_16 L1_N255 L2_N16 1.8483588252e+05
R_Dense_2_256_16 L1_N256 L2_N16 5.2490459101e+05
R_Dense_2_257_16 L1_N257 L2_N16 1.0265240194e+05
R_Dense_2_258_16 L1_N258 L2_N16 1.0235413558e+06
R_Dense_2_259_16 L1_N259 L2_N16 1.6552076029e+06
R_Dense_2_260_16 L1_N260 L2_N16 1.8661338905e+05
R_Dense_2_261_16 L1_N261 L2_N16 5.3849193347e+06
R_Dense_2_262_16 L1_N262 L2_N16 1.0553851281e+05
R_Dense_2_263_16 L1_N263 L2_N16 1.4134894388e+05
R_Dense_2_264_16 L1_N264 L2_N16 5.4670508738e+05
R_Dense_2_265_16 L1_N265 L2_N16 2.0014517969e+05
R_Dense_2_266_16 L1_N266 L2_N16 2.8535519090e+05
R_Dense_2_267_16 L1_N267 L2_N16 1.2878185162e+05
R_Dense_2_268_16 L1_N268 L2_N16 3.8347826165e+05
R_Dense_2_269_16 L1_N269 L2_N16 1.3743268611e+05
R_Dense_2_270_16 L1_N270 L2_N16 3.6160212951e+05
R_Dense_2_271_16 L1_N271 L2_N16 1.1252016737e+05
R_Dense_2_272_16 L1_N272 L2_N16 7.8479407460e+05
R_Dense_2_273_16 L1_N273 L2_N16 1.3679625749e+05
R_Dense_2_274_16 L1_N274 L2_N16 1.7789964467e+05
R_Dense_2_275_16 L1_N275 L2_N16 7.4591035621e+05
R_Dense_2_276_16 L1_N276 L2_N16 3.8692841548e+05
R_Dense_2_277_16 L1_N277 L2_N16 4.5002562797e+05
R_Dense_2_278_16 L1_N278 L2_N16 2.2009160149e+05
R_Dense_2_279_16 L1_N279 L2_N16 1.3599387304e+05
R_Dense_2_280_16 L1_N280 L2_N16 1.1659677299e+06
R_Dense_2_281_16 L1_N281 L2_N16 1.1297750752e+05
R_Dense_2_282_16 L1_N282 L2_N16 2.9119788952e+05
R_Dense_2_283_16 L1_N283 L2_N16 3.5738949223e+05
R_Dense_2_284_16 L1_N284 L2_N16 1.6828686170e+05
R_Dense_2_285_16 L1_N285 L2_N16 8.7442807307e+05
R_Dense_2_286_16 L1_N286 L2_N16 1.9556876943e+05
R_Dense_2_287_16 L1_N287 L2_N16 1.0470287832e+05
R_Dense_2_288_16 L1_N288 L2_N16 1.0547658947e+05
R_Dense_2_289_16 L1_N289 L2_N16 1.9072018646e+05
R_Dense_2_290_16 L1_N290 L2_N16 1.3218621108e+05
R_Dense_2_291_16 L1_N291 L2_N16 2.2681265120e+06
R_Dense_2_292_16 L1_N292 L2_N16 3.4549421763e+05
R_Dense_2_293_16 L1_N293 L2_N16 4.8539323492e+05
R_Dense_2_294_16 L1_N294 L2_N16 1.9616262821e+05
R_Dense_2_295_16 L1_N295 L2_N16 1.4618724246e+05
R_Dense_2_296_16 L1_N296 L2_N16 1.8507012733e+05
R_Dense_2_297_16 L1_N297 L2_N16 1.1195999517e+05
R_Dense_2_298_16 L1_N298 L2_N16 1.1870577154e+05
R_Dense_2_299_16 L1_N299 L2_N16 3.6893185554e+06
R_Dense_2_300_16 L1_N300 L2_N16 1.1187753583e+05
R_Dense_2_301_16 L1_N301 L2_N16 2.0315141950e+05
R_Dense_2_302_16 L1_N302 L2_N16 1.9550815439e+05
R_Dense_2_303_16 L1_N303 L2_N16 1.0917776297e+05
R_Dense_2_304_16 L1_N304 L2_N16 8.3047135164e+05
R_Dense_2_305_16 L1_N305 L2_N16 2.4415300613e+05
R_Dense_2_306_16 L1_N306 L2_N16 6.8098813846e+05
R_Dense_2_307_16 L1_N307 L2_N16 1.6507175895e+05
R_Dense_2_308_16 L1_N308 L2_N16 2.1844802935e+05
R_Dense_2_309_16 L1_N309 L2_N16 2.1519710815e+05
R_Dense_2_310_16 L1_N310 L2_N16 1.3219560457e+05
R_Dense_2_311_16 L1_N311 L2_N16 2.9204566965e+06
R_Dense_2_312_16 L1_N312 L2_N16 1.4539508543e+05
R_Dense_2_313_16 L1_N313 L2_N16 2.1254578409e+05
R_Dense_2_314_16 L1_N314 L2_N16 1.1549667239e+05
R_Dense_2_315_16 L1_N315 L2_N16 1.0211779457e+05
R_Dense_2_316_16 L1_N316 L2_N16 2.3890885732e+05
R_Dense_2_317_16 L1_N317 L2_N16 5.6106642501e+05
R_Dense_2_318_16 L1_N318 L2_N16 1.6395345583e+05
R_Dense_2_319_16 L1_N319 L2_N16 2.8293152925e+05
R_Dense_2_320_16 L1_N320 L2_N16 3.1142002932e+05
R_Dense_2_321_16 L1_N321 L2_N16 1.0395821094e+06
R_Dense_2_322_16 L1_N322 L2_N16 1.1431547765e+05
R_Dense_2_323_16 L1_N323 L2_N16 2.1386574231e+05
R_Dense_2_324_16 L1_N324 L2_N16 1.1442651658e+05
R_Dense_2_325_16 L1_N325 L2_N16 1.6032830099e+05
R_Dense_2_326_16 L1_N326 L2_N16 4.2492526486e+05
R_Dense_2_327_16 L1_N327 L2_N16 1.3730328031e+05
R_Dense_2_328_16 L1_N328 L2_N16 1.8628101056e+05
R_Dense_2_329_16 L1_N329 L2_N16 3.6757106801e+05
R_Dense_2_330_16 L1_N330 L2_N16 2.3359659387e+05
R_Dense_2_331_16 L1_N331 L2_N16 2.1327089138e+05
R_Dense_2_332_16 L1_N332 L2_N16 1.2830794417e+05
R_Dense_2_333_16 L1_N333 L2_N16 1.6823183678e+05
R_Dense_2_334_16 L1_N334 L2_N16 3.9184930758e+06
R_Dense_2_335_16 L1_N335 L2_N16 1.0234537222e+05
R_Dense_2_336_16 L1_N336 L2_N16 2.7305550211e+05
R_Dense_2_337_16 L1_N337 L2_N16 1.2770304052e+05
*
R_Dense_2_0_17 L1_N0 L2_N17 1.1488339314e+06
R_Dense_2_1_17 L1_N1 L2_N17 1.8988221637e+06
R_Dense_2_2_17 L1_N2 L2_N17 1.0064684944e+05
R_Dense_2_3_17 L1_N3 L2_N17 1.9494157311e+05
R_Dense_2_4_17 L1_N4 L2_N17 4.6255025132e+05
R_Dense_2_5_17 L1_N5 L2_N17 3.0547016345e+05
R_Dense_2_6_17 L1_N6 L2_N17 3.7813415590e+05
R_Dense_2_7_17 L1_N7 L2_N17 2.6796967422e+06
R_Dense_2_8_17 L1_N8 L2_N17 3.1211124919e+05
R_Dense_2_9_17 L1_N9 L2_N17 5.2319370875e+05
R_Dense_2_10_17 L1_N10 L2_N17 7.9637408406e+06
R_Dense_2_11_17 L1_N11 L2_N17 1.1005761063e+05
R_Dense_2_12_17 L1_N12 L2_N17 2.5732956788e+05
R_Dense_2_13_17 L1_N13 L2_N17 1.5585666052e+05
R_Dense_2_14_17 L1_N14 L2_N17 3.2854789496e+05
R_Dense_2_15_17 L1_N15 L2_N17 2.0821386257e+05
R_Dense_2_16_17 L1_N16 L2_N17 3.1932100852e+05
R_Dense_2_17_17 L1_N17 L2_N17 2.8377166412e+06
R_Dense_2_18_17 L1_N18 L2_N17 2.7066726780e+05
R_Dense_2_19_17 L1_N19 L2_N17 1.4515953977e+05
R_Dense_2_20_17 L1_N20 L2_N17 3.5152145594e+05
R_Dense_2_21_17 L1_N21 L2_N17 1.4791897972e+05
R_Dense_2_22_17 L1_N22 L2_N17 3.4835237260e+05
R_Dense_2_23_17 L1_N23 L2_N17 1.7742233153e+06
R_Dense_2_24_17 L1_N24 L2_N17 4.6048823914e+05
R_Dense_2_25_17 L1_N25 L2_N17 1.3164414279e+05
R_Dense_2_26_17 L1_N26 L2_N17 1.7900771822e+05
R_Dense_2_27_17 L1_N27 L2_N17 5.7900084305e+05
R_Dense_2_28_17 L1_N28 L2_N17 2.3825627631e+05
R_Dense_2_29_17 L1_N29 L2_N17 2.6370020910e+05
R_Dense_2_30_17 L1_N30 L2_N17 1.0112853726e+05
R_Dense_2_31_17 L1_N31 L2_N17 1.6895999230e+06
R_Dense_2_32_17 L1_N32 L2_N17 1.8931587710e+05
R_Dense_2_33_17 L1_N33 L2_N17 1.9827110595e+06
R_Dense_2_34_17 L1_N34 L2_N17 1.0035454518e+05
R_Dense_2_35_17 L1_N35 L2_N17 1.3622716194e+05
R_Dense_2_36_17 L1_N36 L2_N17 1.0611315638e+05
R_Dense_2_37_17 L1_N37 L2_N17 1.2685014304e+05
R_Dense_2_38_17 L1_N38 L2_N17 1.3300047241e+05
R_Dense_2_39_17 L1_N39 L2_N17 1.3013643018e+05
R_Dense_2_40_17 L1_N40 L2_N17 1.0601985863e+05
R_Dense_2_41_17 L1_N41 L2_N17 2.3954248217e+05
R_Dense_2_42_17 L1_N42 L2_N17 1.8375759633e+05
R_Dense_2_43_17 L1_N43 L2_N17 6.2613456178e+05
R_Dense_2_44_17 L1_N44 L2_N17 3.9668346011e+05
R_Dense_2_45_17 L1_N45 L2_N17 2.6138964500e+05
R_Dense_2_46_17 L1_N46 L2_N17 1.0384476657e+05
R_Dense_2_47_17 L1_N47 L2_N17 6.0253806551e+05
R_Dense_2_48_17 L1_N48 L2_N17 1.8080310644e+05
R_Dense_2_49_17 L1_N49 L2_N17 2.2870703410e+05
R_Dense_2_50_17 L1_N50 L2_N17 7.2880747719e+05
R_Dense_2_51_17 L1_N51 L2_N17 1.2117209885e+05
R_Dense_2_52_17 L1_N52 L2_N17 2.1654049042e+05
R_Dense_2_53_17 L1_N53 L2_N17 1.8399447402e+05
R_Dense_2_54_17 L1_N54 L2_N17 2.7508610962e+05
R_Dense_2_55_17 L1_N55 L2_N17 1.4102394065e+06
R_Dense_2_56_17 L1_N56 L2_N17 1.7798271571e+05
R_Dense_2_57_17 L1_N57 L2_N17 2.8487389663e+05
R_Dense_2_58_17 L1_N58 L2_N17 3.3090170123e+05
R_Dense_2_59_17 L1_N59 L2_N17 1.1895251366e+05
R_Dense_2_60_17 L1_N60 L2_N17 2.0279872876e+05
R_Dense_2_61_17 L1_N61 L2_N17 1.4214352298e+05
R_Dense_2_62_17 L1_N62 L2_N17 1.9832864435e+05
R_Dense_2_63_17 L1_N63 L2_N17 3.2704907545e+05
R_Dense_2_64_17 L1_N64 L2_N17 1.1284232884e+05
R_Dense_2_65_17 L1_N65 L2_N17 2.9279877397e+06
R_Dense_2_66_17 L1_N66 L2_N17 1.3360207618e+05
R_Dense_2_67_17 L1_N67 L2_N17 1.3695367155e+05
R_Dense_2_68_17 L1_N68 L2_N17 1.6494133033e+05
R_Dense_2_69_17 L1_N69 L2_N17 1.6062848781e+05
R_Dense_2_70_17 L1_N70 L2_N17 1.2577414744e+05
R_Dense_2_71_17 L1_N71 L2_N17 6.7537377522e+05
R_Dense_2_72_17 L1_N72 L2_N17 1.1071421948e+05
R_Dense_2_73_17 L1_N73 L2_N17 6.6266507960e+06
R_Dense_2_74_17 L1_N74 L2_N17 8.4729206330e+05
R_Dense_2_75_17 L1_N75 L2_N17 4.1131287610e+05
R_Dense_2_76_17 L1_N76 L2_N17 1.8896318743e+05
R_Dense_2_77_17 L1_N77 L2_N17 1.7572765605e+05
R_Dense_2_78_17 L1_N78 L2_N17 2.4507130760e+05
R_Dense_2_79_17 L1_N79 L2_N17 1.2130343425e+05
R_Dense_2_80_17 L1_N80 L2_N17 5.1786436058e+05
R_Dense_2_81_17 L1_N81 L2_N17 2.1054224236e+05
R_Dense_2_82_17 L1_N82 L2_N17 3.0627968490e+06
R_Dense_2_83_17 L1_N83 L2_N17 1.0713705570e+05
R_Dense_2_84_17 L1_N84 L2_N17 1.1976029359e+05
R_Dense_2_85_17 L1_N85 L2_N17 3.5828654661e+05
R_Dense_2_86_17 L1_N86 L2_N17 1.0111083603e+05
R_Dense_2_87_17 L1_N87 L2_N17 1.5770744032e+05
R_Dense_2_88_17 L1_N88 L2_N17 2.9061373630e+05
R_Dense_2_89_17 L1_N89 L2_N17 1.0202448890e+05
R_Dense_2_90_17 L1_N90 L2_N17 1.9183793298e+05
R_Dense_2_91_17 L1_N91 L2_N17 1.4253406414e+05
R_Dense_2_92_17 L1_N92 L2_N17 7.6963222008e+05
R_Dense_2_93_17 L1_N93 L2_N17 1.2912642882e+05
R_Dense_2_94_17 L1_N94 L2_N17 3.8854983657e+05
R_Dense_2_95_17 L1_N95 L2_N17 2.2727106414e+05
R_Dense_2_96_17 L1_N96 L2_N17 1.9543526577e+05
R_Dense_2_97_17 L1_N97 L2_N17 1.1439761917e+05
R_Dense_2_98_17 L1_N98 L2_N17 1.4564194218e+05
R_Dense_2_99_17 L1_N99 L2_N17 1.5199483745e+05
R_Dense_2_100_17 L1_N100 L2_N17 2.0830891091e+05
R_Dense_2_101_17 L1_N101 L2_N17 1.5393140774e+05
R_Dense_2_102_17 L1_N102 L2_N17 1.1841951576e+05
R_Dense_2_103_17 L1_N103 L2_N17 2.6742535557e+05
R_Dense_2_104_17 L1_N104 L2_N17 1.0301306610e+05
R_Dense_2_105_17 L1_N105 L2_N17 1.0400367602e+05
R_Dense_2_106_17 L1_N106 L2_N17 1.0004991398e+05
R_Dense_2_107_17 L1_N107 L2_N17 1.0960257062e+05
R_Dense_2_108_17 L1_N108 L2_N17 9.0430705293e+06
R_Dense_2_109_17 L1_N109 L2_N17 2.2748724924e+05
R_Dense_2_110_17 L1_N110 L2_N17 1.6672887425e+05
R_Dense_2_111_17 L1_N111 L2_N17 3.6132003346e+05
R_Dense_2_112_17 L1_N112 L2_N17 1.2598372648e+05
R_Dense_2_113_17 L1_N113 L2_N17 6.0691112819e+05
R_Dense_2_114_17 L1_N114 L2_N17 1.1863804834e+05
R_Dense_2_115_17 L1_N115 L2_N17 1.5391273868e+05
R_Dense_2_116_17 L1_N116 L2_N17 1.0897097674e+05
R_Dense_2_117_17 L1_N117 L2_N17 7.2328096181e+05
R_Dense_2_118_17 L1_N118 L2_N17 1.1331888949e+05
R_Dense_2_119_17 L1_N119 L2_N17 5.4345422274e+05
R_Dense_2_120_17 L1_N120 L2_N17 1.0531603068e+06
R_Dense_2_121_17 L1_N121 L2_N17 1.6653412083e+05
R_Dense_2_122_17 L1_N122 L2_N17 3.1462099280e+06
R_Dense_2_123_17 L1_N123 L2_N17 1.1197141806e+05
R_Dense_2_124_17 L1_N124 L2_N17 1.4950290356e+05
R_Dense_2_125_17 L1_N125 L2_N17 1.1016515106e+05
R_Dense_2_126_17 L1_N126 L2_N17 2.1959264609e+05
R_Dense_2_127_17 L1_N127 L2_N17 1.4667204087e+05
R_Dense_2_128_17 L1_N128 L2_N17 7.3667815188e+05
R_Dense_2_129_17 L1_N129 L2_N17 2.4378422953e+05
R_Dense_2_130_17 L1_N130 L2_N17 1.1321700358e+05
R_Dense_2_131_17 L1_N131 L2_N17 5.1769822883e+05
R_Dense_2_132_17 L1_N132 L2_N17 1.2511818947e+05
R_Dense_2_133_17 L1_N133 L2_N17 2.0701614863e+05
R_Dense_2_134_17 L1_N134 L2_N17 2.4012410376e+05
R_Dense_2_135_17 L1_N135 L2_N17 2.8578713551e+06
R_Dense_2_136_17 L1_N136 L2_N17 9.4642364359e+06
R_Dense_2_137_17 L1_N137 L2_N17 1.4991413437e+05
R_Dense_2_138_17 L1_N138 L2_N17 1.0174080620e+05
R_Dense_2_139_17 L1_N139 L2_N17 1.9069400978e+05
R_Dense_2_140_17 L1_N140 L2_N17 2.2214756419e+06
R_Dense_2_141_17 L1_N141 L2_N17 1.8981776728e+05
R_Dense_2_142_17 L1_N142 L2_N17 1.0554602659e+05
R_Dense_2_143_17 L1_N143 L2_N17 1.3383282985e+05
R_Dense_2_144_17 L1_N144 L2_N17 2.6947717472e+05
R_Dense_2_145_17 L1_N145 L2_N17 3.4013560540e+05
R_Dense_2_146_17 L1_N146 L2_N17 3.4182504336e+05
R_Dense_2_147_17 L1_N147 L2_N17 2.8611537908e+05
R_Dense_2_148_17 L1_N148 L2_N17 1.3939196672e+05
R_Dense_2_149_17 L1_N149 L2_N17 1.0767311027e+06
R_Dense_2_150_17 L1_N150 L2_N17 3.9343619441e+06
R_Dense_2_151_17 L1_N151 L2_N17 2.0194801663e+05
R_Dense_2_152_17 L1_N152 L2_N17 2.2749514677e+05
R_Dense_2_153_17 L1_N153 L2_N17 2.9388916535e+05
R_Dense_2_154_17 L1_N154 L2_N17 2.3274978596e+05
R_Dense_2_155_17 L1_N155 L2_N17 2.1212644001e+05
R_Dense_2_156_17 L1_N156 L2_N17 1.8344256609e+05
R_Dense_2_157_17 L1_N157 L2_N17 1.0018190868e+06
R_Dense_2_158_17 L1_N158 L2_N17 2.7370291771e+05
R_Dense_2_159_17 L1_N159 L2_N17 4.0275535457e+05
R_Dense_2_160_17 L1_N160 L2_N17 6.0802547641e+05
R_Dense_2_161_17 L1_N161 L2_N17 2.9764486535e+05
R_Dense_2_162_17 L1_N162 L2_N17 1.7763365136e+05
R_Dense_2_163_17 L1_N163 L2_N17 1.1040458824e+05
R_Dense_2_164_17 L1_N164 L2_N17 2.3754389908e+05
R_Dense_2_165_17 L1_N165 L2_N17 3.3768314937e+05
R_Dense_2_166_17 L1_N166 L2_N17 2.4936296739e+05
R_Dense_2_167_17 L1_N167 L2_N17 2.8629573038e+05
R_Dense_2_168_17 L1_N168 L2_N17 3.3073304192e+05
R_Dense_2_169_17 L1_N169 L2_N17 1.3582493724e+05
R_Dense_2_170_17 L1_N170 L2_N17 2.1525689263e+05
R_Dense_2_171_17 L1_N171 L2_N17 3.1508004857e+05
R_Dense_2_172_17 L1_N172 L2_N17 3.7892819060e+05
R_Dense_2_173_17 L1_N173 L2_N17 2.8399315871e+05
R_Dense_2_174_17 L1_N174 L2_N17 1.3212109218e+05
R_Dense_2_175_17 L1_N175 L2_N17 1.6369943733e+05
R_Dense_2_176_17 L1_N176 L2_N17 2.0729511415e+05
R_Dense_2_177_17 L1_N177 L2_N17 1.4332565610e+05
R_Dense_2_178_17 L1_N178 L2_N17 1.4393574929e+05
R_Dense_2_179_17 L1_N179 L2_N17 3.0347021708e+05
R_Dense_2_180_17 L1_N180 L2_N17 2.0901534698e+05
R_Dense_2_181_17 L1_N181 L2_N17 1.6648754605e+06
R_Dense_2_182_17 L1_N182 L2_N17 1.7045847386e+05
R_Dense_2_183_17 L1_N183 L2_N17 1.7371404090e+05
R_Dense_2_184_17 L1_N184 L2_N17 3.0416570391e+05
R_Dense_2_185_17 L1_N185 L2_N17 1.3078501580e+05
R_Dense_2_186_17 L1_N186 L2_N17 1.1321582244e+05
R_Dense_2_187_17 L1_N187 L2_N17 3.2295646086e+05
R_Dense_2_188_17 L1_N188 L2_N17 3.3085740392e+05
R_Dense_2_189_17 L1_N189 L2_N17 1.4371778357e+05
R_Dense_2_190_17 L1_N190 L2_N17 1.4527741999e+05
R_Dense_2_191_17 L1_N191 L2_N17 2.1163341314e+05
R_Dense_2_192_17 L1_N192 L2_N17 2.7194260377e+05
R_Dense_2_193_17 L1_N193 L2_N17 1.8972864206e+05
R_Dense_2_194_17 L1_N194 L2_N17 1.0204326706e+05
R_Dense_2_195_17 L1_N195 L2_N17 1.9802873065e+05
R_Dense_2_196_17 L1_N196 L2_N17 1.1856729688e+05
R_Dense_2_197_17 L1_N197 L2_N17 1.4804805881e+06
R_Dense_2_198_17 L1_N198 L2_N17 1.1312629552e+05
R_Dense_2_199_17 L1_N199 L2_N17 7.8924618244e+05
R_Dense_2_200_17 L1_N200 L2_N17 1.6034658853e+05
R_Dense_2_201_17 L1_N201 L2_N17 2.5047130008e+05
R_Dense_2_202_17 L1_N202 L2_N17 2.9292874056e+05
R_Dense_2_203_17 L1_N203 L2_N17 4.2223518499e+05
R_Dense_2_204_17 L1_N204 L2_N17 1.0635035941e+05
R_Dense_2_205_17 L1_N205 L2_N17 1.4469457877e+05
R_Dense_2_206_17 L1_N206 L2_N17 4.0587697903e+05
R_Dense_2_207_17 L1_N207 L2_N17 1.3489610977e+05
R_Dense_2_208_17 L1_N208 L2_N17 1.1205220173e+05
R_Dense_2_209_17 L1_N209 L2_N17 1.9420558919e+06
R_Dense_2_210_17 L1_N210 L2_N17 2.4070960931e+05
R_Dense_2_211_17 L1_N211 L2_N17 5.4033501678e+05
R_Dense_2_212_17 L1_N212 L2_N17 1.0212773872e+05
R_Dense_2_213_17 L1_N213 L2_N17 4.4953186209e+05
R_Dense_2_214_17 L1_N214 L2_N17 1.1606823453e+05
R_Dense_2_215_17 L1_N215 L2_N17 2.6793136695e+05
R_Dense_2_216_17 L1_N216 L2_N17 1.6575378495e+05
R_Dense_2_217_17 L1_N217 L2_N17 1.5698067659e+05
R_Dense_2_218_17 L1_N218 L2_N17 2.2924532338e+05
R_Dense_2_219_17 L1_N219 L2_N17 1.0620281780e+05
R_Dense_2_220_17 L1_N220 L2_N17 2.7263752613e+05
R_Dense_2_221_17 L1_N221 L2_N17 1.2177536255e+05
R_Dense_2_222_17 L1_N222 L2_N17 3.6052593622e+05
R_Dense_2_223_17 L1_N223 L2_N17 1.0055322659e+05
R_Dense_2_224_17 L1_N224 L2_N17 7.3419527926e+06
R_Dense_2_225_17 L1_N225 L2_N17 1.8598320536e+05
R_Dense_2_226_17 L1_N226 L2_N17 2.9258085809e+05
R_Dense_2_227_17 L1_N227 L2_N17 1.1892931322e+05
R_Dense_2_228_17 L1_N228 L2_N17 1.9783051016e+05
R_Dense_2_229_17 L1_N229 L2_N17 1.4217390758e+05
R_Dense_2_230_17 L1_N230 L2_N17 1.9492465878e+05
R_Dense_2_231_17 L1_N231 L2_N17 2.7407774275e+05
R_Dense_2_232_17 L1_N232 L2_N17 2.0140903016e+05
R_Dense_2_233_17 L1_N233 L2_N17 1.6704468259e+05
R_Dense_2_234_17 L1_N234 L2_N17 7.2430682083e+05
R_Dense_2_235_17 L1_N235 L2_N17 3.5242743074e+05
R_Dense_2_236_17 L1_N236 L2_N17 1.0009522263e+05
R_Dense_2_237_17 L1_N237 L2_N17 1.2575258568e+05
R_Dense_2_238_17 L1_N238 L2_N17 1.0176717895e+05
R_Dense_2_239_17 L1_N239 L2_N17 1.9393908141e+05
R_Dense_2_240_17 L1_N240 L2_N17 3.8995637766e+05
R_Dense_2_241_17 L1_N241 L2_N17 1.9525880741e+05
R_Dense_2_242_17 L1_N242 L2_N17 1.3386334258e+05
R_Dense_2_243_17 L1_N243 L2_N17 1.5953360264e+05
R_Dense_2_244_17 L1_N244 L2_N17 3.0077374988e+05
R_Dense_2_245_17 L1_N245 L2_N17 2.5074427339e+05
R_Dense_2_246_17 L1_N246 L2_N17 1.8607881504e+05
R_Dense_2_247_17 L1_N247 L2_N17 2.9395338643e+06
R_Dense_2_248_17 L1_N248 L2_N17 4.8064632010e+05
R_Dense_2_249_17 L1_N249 L2_N17 1.3571883886e+05
R_Dense_2_250_17 L1_N250 L2_N17 1.8074839254e+05
R_Dense_2_251_17 L1_N251 L2_N17 1.5211953568e+05
R_Dense_2_252_17 L1_N252 L2_N17 8.4602485521e+05
R_Dense_2_253_17 L1_N253 L2_N17 2.2400279551e+05
R_Dense_2_254_17 L1_N254 L2_N17 7.6662602740e+05
R_Dense_2_255_17 L1_N255 L2_N17 6.5035228254e+05
R_Dense_2_256_17 L1_N256 L2_N17 1.0147248685e+05
R_Dense_2_257_17 L1_N257 L2_N17 2.0984140728e+05
R_Dense_2_258_17 L1_N258 L2_N17 1.7499379417e+05
R_Dense_2_259_17 L1_N259 L2_N17 4.0393112071e+05
R_Dense_2_260_17 L1_N260 L2_N17 1.2516579206e+05
R_Dense_2_261_17 L1_N261 L2_N17 1.0062079226e+05
R_Dense_2_262_17 L1_N262 L2_N17 1.0870556990e+05
R_Dense_2_263_17 L1_N263 L2_N17 3.6422683458e+05
R_Dense_2_264_17 L1_N264 L2_N17 1.1635275145e+05
R_Dense_2_265_17 L1_N265 L2_N17 3.9239563203e+05
R_Dense_2_266_17 L1_N266 L2_N17 1.1111853341e+05
R_Dense_2_267_17 L1_N267 L2_N17 1.0309851672e+05
R_Dense_2_268_17 L1_N268 L2_N17 1.6735880088e+05
R_Dense_2_269_17 L1_N269 L2_N17 1.4100427589e+05
R_Dense_2_270_17 L1_N270 L2_N17 1.4896333783e+06
R_Dense_2_271_17 L1_N271 L2_N17 8.8393893260e+05
R_Dense_2_272_17 L1_N272 L2_N17 2.6417935460e+05
R_Dense_2_273_17 L1_N273 L2_N17 8.9252847828e+05
R_Dense_2_274_17 L1_N274 L2_N17 1.1330706179e+05
R_Dense_2_275_17 L1_N275 L2_N17 4.1911670253e+05
R_Dense_2_276_17 L1_N276 L2_N17 1.5959015578e+05
R_Dense_2_277_17 L1_N277 L2_N17 3.0608297716e+05
R_Dense_2_278_17 L1_N278 L2_N17 8.1711741371e+05
R_Dense_2_279_17 L1_N279 L2_N17 1.0757913791e+05
R_Dense_2_280_17 L1_N280 L2_N17 6.5539054956e+05
R_Dense_2_281_17 L1_N281 L2_N17 1.4991017611e+05
R_Dense_2_282_17 L1_N282 L2_N17 4.1323632628e+05
R_Dense_2_283_17 L1_N283 L2_N17 5.8872829566e+05
R_Dense_2_284_17 L1_N284 L2_N17 1.7413049768e+05
R_Dense_2_285_17 L1_N285 L2_N17 8.2866502319e+05
R_Dense_2_286_17 L1_N286 L2_N17 1.7283122326e+05
R_Dense_2_287_17 L1_N287 L2_N17 1.7498519848e+05
R_Dense_2_288_17 L1_N288 L2_N17 9.8069821873e+05
R_Dense_2_289_17 L1_N289 L2_N17 1.2647347054e+05
R_Dense_2_290_17 L1_N290 L2_N17 1.4086104192e+05
R_Dense_2_291_17 L1_N291 L2_N17 1.0426939601e+06
R_Dense_2_292_17 L1_N292 L2_N17 1.5812996665e+05
R_Dense_2_293_17 L1_N293 L2_N17 1.0116265969e+05
R_Dense_2_294_17 L1_N294 L2_N17 1.8565678141e+06
R_Dense_2_295_17 L1_N295 L2_N17 1.5125284748e+05
R_Dense_2_296_17 L1_N296 L2_N17 1.8540077239e+05
R_Dense_2_297_17 L1_N297 L2_N17 1.1257832002e+05
R_Dense_2_298_17 L1_N298 L2_N17 1.8113857020e+05
R_Dense_2_299_17 L1_N299 L2_N17 5.4836567223e+05
R_Dense_2_300_17 L1_N300 L2_N17 1.7915197109e+05
R_Dense_2_301_17 L1_N301 L2_N17 2.0323324849e+05
R_Dense_2_302_17 L1_N302 L2_N17 1.3387725390e+06
R_Dense_2_303_17 L1_N303 L2_N17 1.4978630002e+06
R_Dense_2_304_17 L1_N304 L2_N17 1.6000455290e+05
R_Dense_2_305_17 L1_N305 L2_N17 1.0469960138e+06
R_Dense_2_306_17 L1_N306 L2_N17 1.1343352799e+05
R_Dense_2_307_17 L1_N307 L2_N17 1.3334385377e+05
R_Dense_2_308_17 L1_N308 L2_N17 1.3533739639e+05
R_Dense_2_309_17 L1_N309 L2_N17 1.8355373732e+05
R_Dense_2_310_17 L1_N310 L2_N17 2.7761391383e+05
R_Dense_2_311_17 L1_N311 L2_N17 4.2823913778e+05
R_Dense_2_312_17 L1_N312 L2_N17 1.3021867616e+05
R_Dense_2_313_17 L1_N313 L2_N17 1.0309989986e+05
R_Dense_2_314_17 L1_N314 L2_N17 1.6221643284e+05
R_Dense_2_315_17 L1_N315 L2_N17 1.5872659194e+05
R_Dense_2_316_17 L1_N316 L2_N17 2.4853580722e+05
R_Dense_2_317_17 L1_N317 L2_N17 1.2627901548e+05
R_Dense_2_318_17 L1_N318 L2_N17 4.9734978987e+05
R_Dense_2_319_17 L1_N319 L2_N17 1.1429604506e+05
R_Dense_2_320_17 L1_N320 L2_N17 2.9226115256e+05
R_Dense_2_321_17 L1_N321 L2_N17 6.0503285995e+05
R_Dense_2_322_17 L1_N322 L2_N17 5.9810520791e+05
R_Dense_2_323_17 L1_N323 L2_N17 1.9743527998e+05
R_Dense_2_324_17 L1_N324 L2_N17 1.7030610567e+05
R_Dense_2_325_17 L1_N325 L2_N17 4.7025775673e+05
R_Dense_2_326_17 L1_N326 L2_N17 6.2536607114e+05
R_Dense_2_327_17 L1_N327 L2_N17 1.8202692645e+05
R_Dense_2_328_17 L1_N328 L2_N17 4.1647973886e+05
R_Dense_2_329_17 L1_N329 L2_N17 2.3372499447e+05
R_Dense_2_330_17 L1_N330 L2_N17 1.7272805365e+05
R_Dense_2_331_17 L1_N331 L2_N17 2.1795920414e+05
R_Dense_2_332_17 L1_N332 L2_N17 4.9445544552e+05
R_Dense_2_333_17 L1_N333 L2_N17 1.1300359634e+05
R_Dense_2_334_17 L1_N334 L2_N17 2.7000743354e+06
R_Dense_2_335_17 L1_N335 L2_N17 1.9046232815e+05
R_Dense_2_336_17 L1_N336 L2_N17 1.4739309757e+05
R_Dense_2_337_17 L1_N337 L2_N17 5.0939354599e+05
*
R_Dense_2_0_18 L1_N0 L2_N18 3.5804093540e+05
R_Dense_2_1_18 L1_N1 L2_N18 1.8056877933e+05
R_Dense_2_2_18 L1_N2 L2_N18 1.6697602450e+05
R_Dense_2_3_18 L1_N3 L2_N18 3.0805496586e+05
R_Dense_2_4_18 L1_N4 L2_N18 1.2421503581e+05
R_Dense_2_5_18 L1_N5 L2_N18 1.5684739078e+05
R_Dense_2_6_18 L1_N6 L2_N18 4.0926879018e+05
R_Dense_2_7_18 L1_N7 L2_N18 1.8311389474e+05
R_Dense_2_8_18 L1_N8 L2_N18 2.3653326917e+05
R_Dense_2_9_18 L1_N9 L2_N18 2.4529942416e+05
R_Dense_2_10_18 L1_N10 L2_N18 1.2222743029e+05
R_Dense_2_11_18 L1_N11 L2_N18 1.2704084457e+05
R_Dense_2_12_18 L1_N12 L2_N18 2.4692340844e+05
R_Dense_2_13_18 L1_N13 L2_N18 2.7636815744e+05
R_Dense_2_14_18 L1_N14 L2_N18 1.9125746555e+05
R_Dense_2_15_18 L1_N15 L2_N18 4.5087232674e+05
R_Dense_2_16_18 L1_N16 L2_N18 1.8542622259e+05
R_Dense_2_17_18 L1_N17 L2_N18 1.9693388520e+05
R_Dense_2_18_18 L1_N18 L2_N18 2.3983597432e+05
R_Dense_2_19_18 L1_N19 L2_N18 2.1595902183e+06
R_Dense_2_20_18 L1_N20 L2_N18 2.0415725939e+05
R_Dense_2_21_18 L1_N21 L2_N18 1.2171083314e+05
R_Dense_2_22_18 L1_N22 L2_N18 1.6369091380e+05
R_Dense_2_23_18 L1_N23 L2_N18 1.7589510318e+05
R_Dense_2_24_18 L1_N24 L2_N18 1.2161153937e+05
R_Dense_2_25_18 L1_N25 L2_N18 4.6254481621e+05
R_Dense_2_26_18 L1_N26 L2_N18 1.2521750430e+05
R_Dense_2_27_18 L1_N27 L2_N18 1.8354028644e+05
R_Dense_2_28_18 L1_N28 L2_N18 1.0250540577e+05
R_Dense_2_29_18 L1_N29 L2_N18 2.1076385001e+05
R_Dense_2_30_18 L1_N30 L2_N18 1.2840154799e+05
R_Dense_2_31_18 L1_N31 L2_N18 1.6653933893e+05
R_Dense_2_32_18 L1_N32 L2_N18 2.0379939510e+05
R_Dense_2_33_18 L1_N33 L2_N18 2.3148901004e+05
R_Dense_2_34_18 L1_N34 L2_N18 2.6117203908e+05
R_Dense_2_35_18 L1_N35 L2_N18 3.2022155215e+05
R_Dense_2_36_18 L1_N36 L2_N18 1.1242139939e+05
R_Dense_2_37_18 L1_N37 L2_N18 2.2065876342e+05
R_Dense_2_38_18 L1_N38 L2_N18 1.9735274239e+06
R_Dense_2_39_18 L1_N39 L2_N18 1.9599127181e+05
R_Dense_2_40_18 L1_N40 L2_N18 1.8612801041e+05
R_Dense_2_41_18 L1_N41 L2_N18 4.3096845083e+05
R_Dense_2_42_18 L1_N42 L2_N18 1.4266129622e+05
R_Dense_2_43_18 L1_N43 L2_N18 4.0236061145e+05
R_Dense_2_44_18 L1_N44 L2_N18 1.3242595156e+05
R_Dense_2_45_18 L1_N45 L2_N18 1.7372257524e+05
R_Dense_2_46_18 L1_N46 L2_N18 6.7139292046e+05
R_Dense_2_47_18 L1_N47 L2_N18 2.9653512410e+05
R_Dense_2_48_18 L1_N48 L2_N18 1.6597273461e+06
R_Dense_2_49_18 L1_N49 L2_N18 2.6229526238e+05
R_Dense_2_50_18 L1_N50 L2_N18 1.1437210849e+05
R_Dense_2_51_18 L1_N51 L2_N18 3.4126482139e+05
R_Dense_2_52_18 L1_N52 L2_N18 2.9488963062e+05
R_Dense_2_53_18 L1_N53 L2_N18 1.0954473933e+06
R_Dense_2_54_18 L1_N54 L2_N18 1.0676688859e+05
R_Dense_2_55_18 L1_N55 L2_N18 1.2215923899e+05
R_Dense_2_56_18 L1_N56 L2_N18 1.1314553807e+05
R_Dense_2_57_18 L1_N57 L2_N18 1.0338759738e+05
R_Dense_2_58_18 L1_N58 L2_N18 2.3923868861e+05
R_Dense_2_59_18 L1_N59 L2_N18 4.3197476148e+05
R_Dense_2_60_18 L1_N60 L2_N18 1.5862144754e+05
R_Dense_2_61_18 L1_N61 L2_N18 1.3170633366e+05
R_Dense_2_62_18 L1_N62 L2_N18 3.1642064261e+05
R_Dense_2_63_18 L1_N63 L2_N18 2.0171958821e+05
R_Dense_2_64_18 L1_N64 L2_N18 2.4027398473e+05
R_Dense_2_65_18 L1_N65 L2_N18 9.7801313460e+05
R_Dense_2_66_18 L1_N66 L2_N18 1.0302596951e+05
R_Dense_2_67_18 L1_N67 L2_N18 2.5345674037e+05
R_Dense_2_68_18 L1_N68 L2_N18 1.7543899225e+05
R_Dense_2_69_18 L1_N69 L2_N18 1.5878271661e+05
R_Dense_2_70_18 L1_N70 L2_N18 5.0371319171e+05
R_Dense_2_71_18 L1_N71 L2_N18 1.7900807169e+05
R_Dense_2_72_18 L1_N72 L2_N18 1.0076546118e+05
R_Dense_2_73_18 L1_N73 L2_N18 1.2858111963e+05
R_Dense_2_74_18 L1_N74 L2_N18 1.2539701532e+05
R_Dense_2_75_18 L1_N75 L2_N18 2.1088812926e+05
R_Dense_2_76_18 L1_N76 L2_N18 2.5660577598e+05
R_Dense_2_77_18 L1_N77 L2_N18 1.3679253812e+05
R_Dense_2_78_18 L1_N78 L2_N18 1.6470801678e+05
R_Dense_2_79_18 L1_N79 L2_N18 1.8176372929e+05
R_Dense_2_80_18 L1_N80 L2_N18 1.4625242155e+05
R_Dense_2_81_18 L1_N81 L2_N18 1.2238814627e+05
R_Dense_2_82_18 L1_N82 L2_N18 4.6851662896e+05
R_Dense_2_83_18 L1_N83 L2_N18 1.7764193445e+06
R_Dense_2_84_18 L1_N84 L2_N18 1.4037828112e+06
R_Dense_2_85_18 L1_N85 L2_N18 1.0743128008e+05
R_Dense_2_86_18 L1_N86 L2_N18 2.7400323967e+05
R_Dense_2_87_18 L1_N87 L2_N18 1.1881449790e+05
R_Dense_2_88_18 L1_N88 L2_N18 1.5083346143e+05
R_Dense_2_89_18 L1_N89 L2_N18 1.0274461455e+05
R_Dense_2_90_18 L1_N90 L2_N18 1.8587133143e+05
R_Dense_2_91_18 L1_N91 L2_N18 1.6455682723e+05
R_Dense_2_92_18 L1_N92 L2_N18 1.7648609629e+05
R_Dense_2_93_18 L1_N93 L2_N18 5.8563555919e+05
R_Dense_2_94_18 L1_N94 L2_N18 1.9272805875e+05
R_Dense_2_95_18 L1_N95 L2_N18 6.5159281233e+05
R_Dense_2_96_18 L1_N96 L2_N18 3.4644050569e+05
R_Dense_2_97_18 L1_N97 L2_N18 1.9675530856e+05
R_Dense_2_98_18 L1_N98 L2_N18 2.7061638266e+06
R_Dense_2_99_18 L1_N99 L2_N18 1.9729431427e+05
R_Dense_2_100_18 L1_N100 L2_N18 1.1438747155e+05
R_Dense_2_101_18 L1_N101 L2_N18 1.7975257857e+05
R_Dense_2_102_18 L1_N102 L2_N18 2.0817830141e+05
R_Dense_2_103_18 L1_N103 L2_N18 1.4768330221e+05
R_Dense_2_104_18 L1_N104 L2_N18 2.9692195997e+05
R_Dense_2_105_18 L1_N105 L2_N18 7.3533736042e+06
R_Dense_2_106_18 L1_N106 L2_N18 4.6371053724e+05
R_Dense_2_107_18 L1_N107 L2_N18 6.4391918372e+05
R_Dense_2_108_18 L1_N108 L2_N18 1.1843826074e+05
R_Dense_2_109_18 L1_N109 L2_N18 6.3019118174e+05
R_Dense_2_110_18 L1_N110 L2_N18 4.6550883901e+05
R_Dense_2_111_18 L1_N111 L2_N18 1.5266284976e+05
R_Dense_2_112_18 L1_N112 L2_N18 1.9913050404e+05
R_Dense_2_113_18 L1_N113 L2_N18 1.5758838859e+05
R_Dense_2_114_18 L1_N114 L2_N18 1.2318907836e+05
R_Dense_2_115_18 L1_N115 L2_N18 2.0647253858e+05
R_Dense_2_116_18 L1_N116 L2_N18 1.0895876289e+05
R_Dense_2_117_18 L1_N117 L2_N18 4.7974378387e+05
R_Dense_2_118_18 L1_N118 L2_N18 1.9651799941e+05
R_Dense_2_119_18 L1_N119 L2_N18 2.1145050293e+05
R_Dense_2_120_18 L1_N120 L2_N18 1.6153814349e+05
R_Dense_2_121_18 L1_N121 L2_N18 9.3554377616e+05
R_Dense_2_122_18 L1_N122 L2_N18 1.7710262410e+05
R_Dense_2_123_18 L1_N123 L2_N18 1.0588705587e+05
R_Dense_2_124_18 L1_N124 L2_N18 2.0989169265e+05
R_Dense_2_125_18 L1_N125 L2_N18 1.0070989694e+06
R_Dense_2_126_18 L1_N126 L2_N18 3.6912063062e+05
R_Dense_2_127_18 L1_N127 L2_N18 1.6140156620e+05
R_Dense_2_128_18 L1_N128 L2_N18 1.9111439225e+05
R_Dense_2_129_18 L1_N129 L2_N18 2.6848883238e+05
R_Dense_2_130_18 L1_N130 L2_N18 2.1163505034e+05
R_Dense_2_131_18 L1_N131 L2_N18 2.5504245032e+05
R_Dense_2_132_18 L1_N132 L2_N18 3.4811978424e+05
R_Dense_2_133_18 L1_N133 L2_N18 3.0042876983e+05
R_Dense_2_134_18 L1_N134 L2_N18 1.8053062798e+05
R_Dense_2_135_18 L1_N135 L2_N18 1.0810919166e+05
R_Dense_2_136_18 L1_N136 L2_N18 1.3912444856e+05
R_Dense_2_137_18 L1_N137 L2_N18 2.4580403061e+05
R_Dense_2_138_18 L1_N138 L2_N18 1.3473098599e+05
R_Dense_2_139_18 L1_N139 L2_N18 3.3858153518e+05
R_Dense_2_140_18 L1_N140 L2_N18 1.2922107518e+05
R_Dense_2_141_18 L1_N141 L2_N18 4.0965074620e+05
R_Dense_2_142_18 L1_N142 L2_N18 2.3608784028e+05
R_Dense_2_143_18 L1_N143 L2_N18 1.1361016886e+05
R_Dense_2_144_18 L1_N144 L2_N18 4.2201144646e+06
R_Dense_2_145_18 L1_N145 L2_N18 1.6594552037e+05
R_Dense_2_146_18 L1_N146 L2_N18 1.1251618353e+05
R_Dense_2_147_18 L1_N147 L2_N18 4.0457432111e+05
R_Dense_2_148_18 L1_N148 L2_N18 1.4413737287e+05
R_Dense_2_149_18 L1_N149 L2_N18 2.3912113291e+05
R_Dense_2_150_18 L1_N150 L2_N18 2.6996490195e+05
R_Dense_2_151_18 L1_N151 L2_N18 2.9221471611e+05
R_Dense_2_152_18 L1_N152 L2_N18 2.9812250110e+05
R_Dense_2_153_18 L1_N153 L2_N18 3.6196323159e+05
R_Dense_2_154_18 L1_N154 L2_N18 1.0436831384e+05
R_Dense_2_155_18 L1_N155 L2_N18 2.5394696844e+05
R_Dense_2_156_18 L1_N156 L2_N18 1.8427541114e+05
R_Dense_2_157_18 L1_N157 L2_N18 1.7151270825e+05
R_Dense_2_158_18 L1_N158 L2_N18 4.8846537418e+05
R_Dense_2_159_18 L1_N159 L2_N18 3.4964362261e+05
R_Dense_2_160_18 L1_N160 L2_N18 7.1045857909e+05
R_Dense_2_161_18 L1_N161 L2_N18 1.9846451343e+05
R_Dense_2_162_18 L1_N162 L2_N18 1.2244166308e+05
R_Dense_2_163_18 L1_N163 L2_N18 1.1369956332e+05
R_Dense_2_164_18 L1_N164 L2_N18 2.8181120675e+05
R_Dense_2_165_18 L1_N165 L2_N18 4.0750110248e+05
R_Dense_2_166_18 L1_N166 L2_N18 4.5574838248e+05
R_Dense_2_167_18 L1_N167 L2_N18 1.1202769204e+05
R_Dense_2_168_18 L1_N168 L2_N18 1.2791227087e+05
R_Dense_2_169_18 L1_N169 L2_N18 3.4756622195e+05
R_Dense_2_170_18 L1_N170 L2_N18 3.1545838784e+05
R_Dense_2_171_18 L1_N171 L2_N18 3.0672076725e+05
R_Dense_2_172_18 L1_N172 L2_N18 4.6348578666e+05
R_Dense_2_173_18 L1_N173 L2_N18 2.5204184440e+05
R_Dense_2_174_18 L1_N174 L2_N18 3.0856132995e+06
R_Dense_2_175_18 L1_N175 L2_N18 1.4080913806e+05
R_Dense_2_176_18 L1_N176 L2_N18 4.4333864147e+05
R_Dense_2_177_18 L1_N177 L2_N18 7.0492408645e+05
R_Dense_2_178_18 L1_N178 L2_N18 1.2525599576e+05
R_Dense_2_179_18 L1_N179 L2_N18 1.0477199806e+05
R_Dense_2_180_18 L1_N180 L2_N18 2.6092495442e+05
R_Dense_2_181_18 L1_N181 L2_N18 1.2810266983e+05
R_Dense_2_182_18 L1_N182 L2_N18 1.3400605626e+05
R_Dense_2_183_18 L1_N183 L2_N18 4.8545207188e+05
R_Dense_2_184_18 L1_N184 L2_N18 3.0587438204e+05
R_Dense_2_185_18 L1_N185 L2_N18 1.4307541254e+05
R_Dense_2_186_18 L1_N186 L2_N18 1.2799134321e+05
R_Dense_2_187_18 L1_N187 L2_N18 1.2393693512e+05
R_Dense_2_188_18 L1_N188 L2_N18 2.0843858331e+05
R_Dense_2_189_18 L1_N189 L2_N18 1.0317356676e+05
R_Dense_2_190_18 L1_N190 L2_N18 3.2628845418e+05
R_Dense_2_191_18 L1_N191 L2_N18 5.7271199682e+05
R_Dense_2_192_18 L1_N192 L2_N18 1.4428433887e+05
R_Dense_2_193_18 L1_N193 L2_N18 1.3284552263e+05
R_Dense_2_194_18 L1_N194 L2_N18 1.0157421428e+06
R_Dense_2_195_18 L1_N195 L2_N18 1.4412353882e+05
R_Dense_2_196_18 L1_N196 L2_N18 4.0950212475e+05
R_Dense_2_197_18 L1_N197 L2_N18 1.2931415653e+05
R_Dense_2_198_18 L1_N198 L2_N18 1.6618296995e+06
R_Dense_2_199_18 L1_N199 L2_N18 2.7845862894e+05
R_Dense_2_200_18 L1_N200 L2_N18 2.1276887908e+06
R_Dense_2_201_18 L1_N201 L2_N18 3.0776208659e+05
R_Dense_2_202_18 L1_N202 L2_N18 1.1971288840e+05
R_Dense_2_203_18 L1_N203 L2_N18 1.9474736269e+05
R_Dense_2_204_18 L1_N204 L2_N18 1.2228885784e+05
R_Dense_2_205_18 L1_N205 L2_N18 2.7254239449e+05
R_Dense_2_206_18 L1_N206 L2_N18 3.6858517032e+05
R_Dense_2_207_18 L1_N207 L2_N18 3.2426817592e+05
R_Dense_2_208_18 L1_N208 L2_N18 1.3792803010e+05
R_Dense_2_209_18 L1_N209 L2_N18 6.4422453133e+05
R_Dense_2_210_18 L1_N210 L2_N18 3.8691002300e+05
R_Dense_2_211_18 L1_N211 L2_N18 1.0133515679e+05
R_Dense_2_212_18 L1_N212 L2_N18 1.5714557698e+05
R_Dense_2_213_18 L1_N213 L2_N18 1.2073302723e+06
R_Dense_2_214_18 L1_N214 L2_N18 1.1667816775e+06
R_Dense_2_215_18 L1_N215 L2_N18 1.2634515522e+05
R_Dense_2_216_18 L1_N216 L2_N18 1.9858288387e+05
R_Dense_2_217_18 L1_N217 L2_N18 2.1042587846e+05
R_Dense_2_218_18 L1_N218 L2_N18 6.6837174747e+05
R_Dense_2_219_18 L1_N219 L2_N18 1.2286511430e+05
R_Dense_2_220_18 L1_N220 L2_N18 6.6862104945e+05
R_Dense_2_221_18 L1_N221 L2_N18 1.3833247973e+05
R_Dense_2_222_18 L1_N222 L2_N18 1.0288253718e+05
R_Dense_2_223_18 L1_N223 L2_N18 2.3541648859e+05
R_Dense_2_224_18 L1_N224 L2_N18 1.3018524299e+05
R_Dense_2_225_18 L1_N225 L2_N18 9.2706983848e+05
R_Dense_2_226_18 L1_N226 L2_N18 1.5686112376e+05
R_Dense_2_227_18 L1_N227 L2_N18 5.4244020492e+05
R_Dense_2_228_18 L1_N228 L2_N18 1.4873461269e+05
R_Dense_2_229_18 L1_N229 L2_N18 1.2879707347e+05
R_Dense_2_230_18 L1_N230 L2_N18 6.4631634508e+05
R_Dense_2_231_18 L1_N231 L2_N18 2.2496863637e+05
R_Dense_2_232_18 L1_N232 L2_N18 4.4869397933e+05
R_Dense_2_233_18 L1_N233 L2_N18 1.5895180321e+05
R_Dense_2_234_18 L1_N234 L2_N18 1.5285964737e+05
R_Dense_2_235_18 L1_N235 L2_N18 1.4966300842e+05
R_Dense_2_236_18 L1_N236 L2_N18 1.9257189096e+05
R_Dense_2_237_18 L1_N237 L2_N18 2.6686582715e+05
R_Dense_2_238_18 L1_N238 L2_N18 1.0318576989e+05
R_Dense_2_239_18 L1_N239 L2_N18 1.1881643900e+05
R_Dense_2_240_18 L1_N240 L2_N18 1.3675986098e+05
R_Dense_2_241_18 L1_N241 L2_N18 1.2511609138e+05
R_Dense_2_242_18 L1_N242 L2_N18 4.1796117304e+05
R_Dense_2_243_18 L1_N243 L2_N18 9.0853849009e+05
R_Dense_2_244_18 L1_N244 L2_N18 3.3132785425e+06
R_Dense_2_245_18 L1_N245 L2_N18 1.8887709961e+05
R_Dense_2_246_18 L1_N246 L2_N18 5.0898848683e+05
R_Dense_2_247_18 L1_N247 L2_N18 1.6267574088e+05
R_Dense_2_248_18 L1_N248 L2_N18 1.0326049890e+05
R_Dense_2_249_18 L1_N249 L2_N18 1.9755060049e+05
R_Dense_2_250_18 L1_N250 L2_N18 1.1031614245e+05
R_Dense_2_251_18 L1_N251 L2_N18 1.9466389459e+05
R_Dense_2_252_18 L1_N252 L2_N18 1.1343851829e+05
R_Dense_2_253_18 L1_N253 L2_N18 1.6320373202e+05
R_Dense_2_254_18 L1_N254 L2_N18 1.0004752057e+06
R_Dense_2_255_18 L1_N255 L2_N18 2.3537498644e+05
R_Dense_2_256_18 L1_N256 L2_N18 1.4930902959e+05
R_Dense_2_257_18 L1_N257 L2_N18 5.5140676777e+05
R_Dense_2_258_18 L1_N258 L2_N18 1.7860408638e+05
R_Dense_2_259_18 L1_N259 L2_N18 1.7042967258e+05
R_Dense_2_260_18 L1_N260 L2_N18 4.7186771117e+05
R_Dense_2_261_18 L1_N261 L2_N18 2.1376276781e+05
R_Dense_2_262_18 L1_N262 L2_N18 1.1801787535e+05
R_Dense_2_263_18 L1_N263 L2_N18 1.4084630098e+06
R_Dense_2_264_18 L1_N264 L2_N18 1.2025384520e+05
R_Dense_2_265_18 L1_N265 L2_N18 2.0682102505e+05
R_Dense_2_266_18 L1_N266 L2_N18 1.8724126982e+05
R_Dense_2_267_18 L1_N267 L2_N18 1.7122284479e+05
R_Dense_2_268_18 L1_N268 L2_N18 4.8632811842e+05
R_Dense_2_269_18 L1_N269 L2_N18 3.9810396629e+05
R_Dense_2_270_18 L1_N270 L2_N18 1.0073790151e+05
R_Dense_2_271_18 L1_N271 L2_N18 2.9959462527e+05
R_Dense_2_272_18 L1_N272 L2_N18 3.3255168626e+05
R_Dense_2_273_18 L1_N273 L2_N18 3.0573279913e+05
R_Dense_2_274_18 L1_N274 L2_N18 1.3422680508e+05
R_Dense_2_275_18 L1_N275 L2_N18 1.8499777109e+05
R_Dense_2_276_18 L1_N276 L2_N18 1.0626816893e+05
R_Dense_2_277_18 L1_N277 L2_N18 7.7112390681e+05
R_Dense_2_278_18 L1_N278 L2_N18 1.1963783059e+06
R_Dense_2_279_18 L1_N279 L2_N18 3.0311911531e+05
R_Dense_2_280_18 L1_N280 L2_N18 1.6955242363e+05
R_Dense_2_281_18 L1_N281 L2_N18 6.7975849079e+05
R_Dense_2_282_18 L1_N282 L2_N18 1.7608627142e+05
R_Dense_2_283_18 L1_N283 L2_N18 2.8285807147e+05
R_Dense_2_284_18 L1_N284 L2_N18 2.9031009750e+05
R_Dense_2_285_18 L1_N285 L2_N18 1.4207614822e+06
R_Dense_2_286_18 L1_N286 L2_N18 1.5467205288e+05
R_Dense_2_287_18 L1_N287 L2_N18 1.2424328099e+05
R_Dense_2_288_18 L1_N288 L2_N18 2.0676309147e+05
R_Dense_2_289_18 L1_N289 L2_N18 9.3533056363e+05
R_Dense_2_290_18 L1_N290 L2_N18 1.5926479348e+05
R_Dense_2_291_18 L1_N291 L2_N18 1.2375087700e+05
R_Dense_2_292_18 L1_N292 L2_N18 1.3416403172e+05
R_Dense_2_293_18 L1_N293 L2_N18 2.2894782777e+05
R_Dense_2_294_18 L1_N294 L2_N18 1.3690419644e+05
R_Dense_2_295_18 L1_N295 L2_N18 1.5870528434e+06
R_Dense_2_296_18 L1_N296 L2_N18 1.7526779352e+05
R_Dense_2_297_18 L1_N297 L2_N18 3.2515472717e+05
R_Dense_2_298_18 L1_N298 L2_N18 9.9591997098e+05
R_Dense_2_299_18 L1_N299 L2_N18 8.3794790221e+05
R_Dense_2_300_18 L1_N300 L2_N18 1.4847063883e+05
R_Dense_2_301_18 L1_N301 L2_N18 1.3096872848e+05
R_Dense_2_302_18 L1_N302 L2_N18 2.2778363928e+05
R_Dense_2_303_18 L1_N303 L2_N18 5.7990483591e+05
R_Dense_2_304_18 L1_N304 L2_N18 2.2490835193e+05
R_Dense_2_305_18 L1_N305 L2_N18 8.3825698523e+05
R_Dense_2_306_18 L1_N306 L2_N18 6.6693030223e+05
R_Dense_2_307_18 L1_N307 L2_N18 1.3637238391e+05
R_Dense_2_308_18 L1_N308 L2_N18 2.2924478053e+05
R_Dense_2_309_18 L1_N309 L2_N18 5.3308678896e+05
R_Dense_2_310_18 L1_N310 L2_N18 6.0425703893e+05
R_Dense_2_311_18 L1_N311 L2_N18 5.2053969883e+05
R_Dense_2_312_18 L1_N312 L2_N18 8.3898264900e+05
R_Dense_2_313_18 L1_N313 L2_N18 4.6203477920e+05
R_Dense_2_314_18 L1_N314 L2_N18 4.2305195702e+05
R_Dense_2_315_18 L1_N315 L2_N18 1.4656124660e+05
R_Dense_2_316_18 L1_N316 L2_N18 1.3612387586e+05
R_Dense_2_317_18 L1_N317 L2_N18 1.2777885401e+05
R_Dense_2_318_18 L1_N318 L2_N18 1.8597259841e+05
R_Dense_2_319_18 L1_N319 L2_N18 6.4561442382e+05
R_Dense_2_320_18 L1_N320 L2_N18 1.1133762269e+05
R_Dense_2_321_18 L1_N321 L2_N18 1.5237740172e+05
R_Dense_2_322_18 L1_N322 L2_N18 3.5683644000e+05
R_Dense_2_323_18 L1_N323 L2_N18 1.5556826040e+05
R_Dense_2_324_18 L1_N324 L2_N18 1.1455813492e+05
R_Dense_2_325_18 L1_N325 L2_N18 2.0634862955e+05
R_Dense_2_326_18 L1_N326 L2_N18 2.2817910602e+05
R_Dense_2_327_18 L1_N327 L2_N18 1.4452401790e+05
R_Dense_2_328_18 L1_N328 L2_N18 1.0420237209e+05
R_Dense_2_329_18 L1_N329 L2_N18 2.5969253936e+05
R_Dense_2_330_18 L1_N330 L2_N18 3.4266533296e+05
R_Dense_2_331_18 L1_N331 L2_N18 1.1081467503e+05
R_Dense_2_332_18 L1_N332 L2_N18 1.0451061359e+05
R_Dense_2_333_18 L1_N333 L2_N18 2.3023676746e+05
R_Dense_2_334_18 L1_N334 L2_N18 1.0147980515e+05
R_Dense_2_335_18 L1_N335 L2_N18 2.7505808198e+05
R_Dense_2_336_18 L1_N336 L2_N18 1.1489325014e+05
R_Dense_2_337_18 L1_N337 L2_N18 1.7617737462e+05
*
R_Dense_2_0_19 L1_N0 L2_N19 3.1437582376e+05
R_Dense_2_1_19 L1_N1 L2_N19 1.8935446326e+05
R_Dense_2_2_19 L1_N2 L2_N19 5.2756581700e+05
R_Dense_2_3_19 L1_N3 L2_N19 2.3652346702e+05
R_Dense_2_4_19 L1_N4 L2_N19 3.0565835367e+05
R_Dense_2_5_19 L1_N5 L2_N19 1.2521214634e+05
R_Dense_2_6_19 L1_N6 L2_N19 1.6405456560e+05
R_Dense_2_7_19 L1_N7 L2_N19 2.0682651656e+05
R_Dense_2_8_19 L1_N8 L2_N19 1.6692535044e+05
R_Dense_2_9_19 L1_N9 L2_N19 1.0855311102e+05
R_Dense_2_10_19 L1_N10 L2_N19 2.7422033274e+05
R_Dense_2_11_19 L1_N11 L2_N19 1.5823577415e+05
R_Dense_2_12_19 L1_N12 L2_N19 1.8779016032e+05
R_Dense_2_13_19 L1_N13 L2_N19 1.4553289334e+05
R_Dense_2_14_19 L1_N14 L2_N19 2.2733721402e+05
R_Dense_2_15_19 L1_N15 L2_N19 1.1140073178e+05
R_Dense_2_16_19 L1_N16 L2_N19 2.7499255480e+05
R_Dense_2_17_19 L1_N17 L2_N19 1.1445531578e+05
R_Dense_2_18_19 L1_N18 L2_N19 9.6990156229e+05
R_Dense_2_19_19 L1_N19 L2_N19 7.8071750448e+05
R_Dense_2_20_19 L1_N20 L2_N19 1.1256314246e+05
R_Dense_2_21_19 L1_N21 L2_N19 2.2272073645e+05
R_Dense_2_22_19 L1_N22 L2_N19 1.1170153314e+05
R_Dense_2_23_19 L1_N23 L2_N19 1.1902170333e+05
R_Dense_2_24_19 L1_N24 L2_N19 3.8243280339e+05
R_Dense_2_25_19 L1_N25 L2_N19 1.0764369382e+05
R_Dense_2_26_19 L1_N26 L2_N19 2.3009701303e+05
R_Dense_2_27_19 L1_N27 L2_N19 2.3994054331e+05
R_Dense_2_28_19 L1_N28 L2_N19 1.1254030941e+05
R_Dense_2_29_19 L1_N29 L2_N19 1.2412799895e+05
R_Dense_2_30_19 L1_N30 L2_N19 1.7653980295e+05
R_Dense_2_31_19 L1_N31 L2_N19 6.1388758375e+05
R_Dense_2_32_19 L1_N32 L2_N19 1.3580185544e+05
R_Dense_2_33_19 L1_N33 L2_N19 2.8683956396e+05
R_Dense_2_34_19 L1_N34 L2_N19 4.0359089639e+05
R_Dense_2_35_19 L1_N35 L2_N19 3.8636215894e+05
R_Dense_2_36_19 L1_N36 L2_N19 4.9498370396e+05
R_Dense_2_37_19 L1_N37 L2_N19 1.3025314524e+05
R_Dense_2_38_19 L1_N38 L2_N19 2.2099951279e+05
R_Dense_2_39_19 L1_N39 L2_N19 1.3148314582e+05
R_Dense_2_40_19 L1_N40 L2_N19 2.0015774649e+05
R_Dense_2_41_19 L1_N41 L2_N19 1.9512726200e+05
R_Dense_2_42_19 L1_N42 L2_N19 1.3336168076e+05
R_Dense_2_43_19 L1_N43 L2_N19 2.5188542172e+05
R_Dense_2_44_19 L1_N44 L2_N19 1.1275330245e+05
R_Dense_2_45_19 L1_N45 L2_N19 3.6451648136e+05
R_Dense_2_46_19 L1_N46 L2_N19 1.0209740892e+05
R_Dense_2_47_19 L1_N47 L2_N19 7.5970053717e+05
R_Dense_2_48_19 L1_N48 L2_N19 3.9988276967e+05
R_Dense_2_49_19 L1_N49 L2_N19 4.6257357675e+05
R_Dense_2_50_19 L1_N50 L2_N19 1.5867643249e+05
R_Dense_2_51_19 L1_N51 L2_N19 4.5876107597e+05
R_Dense_2_52_19 L1_N52 L2_N19 2.1806601499e+05
R_Dense_2_53_19 L1_N53 L2_N19 1.9277720838e+05
R_Dense_2_54_19 L1_N54 L2_N19 1.8096312333e+05
R_Dense_2_55_19 L1_N55 L2_N19 1.6589282600e+05
R_Dense_2_56_19 L1_N56 L2_N19 1.9682956522e+05
R_Dense_2_57_19 L1_N57 L2_N19 1.7872698292e+05
R_Dense_2_58_19 L1_N58 L2_N19 1.1552144232e+05
R_Dense_2_59_19 L1_N59 L2_N19 1.5228778910e+05
R_Dense_2_60_19 L1_N60 L2_N19 1.1829891904e+05
R_Dense_2_61_19 L1_N61 L2_N19 8.1994716416e+05
R_Dense_2_62_19 L1_N62 L2_N19 4.2399397987e+05
R_Dense_2_63_19 L1_N63 L2_N19 1.4642583818e+05
R_Dense_2_64_19 L1_N64 L2_N19 2.9685699028e+05
R_Dense_2_65_19 L1_N65 L2_N19 5.8722651046e+05
R_Dense_2_66_19 L1_N66 L2_N19 5.6801364294e+05
R_Dense_2_67_19 L1_N67 L2_N19 1.6175147955e+05
R_Dense_2_68_19 L1_N68 L2_N19 1.1498663618e+05
R_Dense_2_69_19 L1_N69 L2_N19 1.0803040902e+05
R_Dense_2_70_19 L1_N70 L2_N19 1.8900233380e+05
R_Dense_2_71_19 L1_N71 L2_N19 2.7962919563e+05
R_Dense_2_72_19 L1_N72 L2_N19 1.6218662465e+05
R_Dense_2_73_19 L1_N73 L2_N19 1.2152475689e+05
R_Dense_2_74_19 L1_N74 L2_N19 2.3179736662e+05
R_Dense_2_75_19 L1_N75 L2_N19 1.8342318421e+05
R_Dense_2_76_19 L1_N76 L2_N19 1.2081474607e+05
R_Dense_2_77_19 L1_N77 L2_N19 6.2764114264e+05
R_Dense_2_78_19 L1_N78 L2_N19 9.1958300141e+06
R_Dense_2_79_19 L1_N79 L2_N19 2.0653603558e+05
R_Dense_2_80_19 L1_N80 L2_N19 1.9854170124e+05
R_Dense_2_81_19 L1_N81 L2_N19 1.0720976819e+05
R_Dense_2_82_19 L1_N82 L2_N19 1.6259798260e+05
R_Dense_2_83_19 L1_N83 L2_N19 3.2869483656e+05
R_Dense_2_84_19 L1_N84 L2_N19 4.1141764876e+05
R_Dense_2_85_19 L1_N85 L2_N19 1.4577459427e+05
R_Dense_2_86_19 L1_N86 L2_N19 4.0709982353e+06
R_Dense_2_87_19 L1_N87 L2_N19 1.3533961226e+05
R_Dense_2_88_19 L1_N88 L2_N19 3.2226550126e+05
R_Dense_2_89_19 L1_N89 L2_N19 2.5584279426e+05
R_Dense_2_90_19 L1_N90 L2_N19 1.3117798466e+05
R_Dense_2_91_19 L1_N91 L2_N19 1.5453291258e+05
R_Dense_2_92_19 L1_N92 L2_N19 1.1663458302e+05
R_Dense_2_93_19 L1_N93 L2_N19 1.0121032048e+05
R_Dense_2_94_19 L1_N94 L2_N19 1.1462674930e+05
R_Dense_2_95_19 L1_N95 L2_N19 1.0093516824e+05
R_Dense_2_96_19 L1_N96 L2_N19 4.0955576391e+05
R_Dense_2_97_19 L1_N97 L2_N19 4.5463683975e+05
R_Dense_2_98_19 L1_N98 L2_N19 1.0727528202e+05
R_Dense_2_99_19 L1_N99 L2_N19 1.2872947183e+06
R_Dense_2_100_19 L1_N100 L2_N19 2.7549906927e+05
R_Dense_2_101_19 L1_N101 L2_N19 2.4045932168e+05
R_Dense_2_102_19 L1_N102 L2_N19 1.3641146022e+05
R_Dense_2_103_19 L1_N103 L2_N19 1.0015201472e+05
R_Dense_2_104_19 L1_N104 L2_N19 2.6468286235e+05
R_Dense_2_105_19 L1_N105 L2_N19 1.0668439404e+05
R_Dense_2_106_19 L1_N106 L2_N19 1.0952147271e+05
R_Dense_2_107_19 L1_N107 L2_N19 8.7956282401e+05
R_Dense_2_108_19 L1_N108 L2_N19 1.4260153406e+05
R_Dense_2_109_19 L1_N109 L2_N19 1.3412472403e+05
R_Dense_2_110_19 L1_N110 L2_N19 1.1789806399e+05
R_Dense_2_111_19 L1_N111 L2_N19 2.4235842548e+05
R_Dense_2_112_19 L1_N112 L2_N19 1.0006212588e+05
R_Dense_2_113_19 L1_N113 L2_N19 3.2202869450e+05
R_Dense_2_114_19 L1_N114 L2_N19 1.2721202904e+05
R_Dense_2_115_19 L1_N115 L2_N19 1.3067913816e+05
R_Dense_2_116_19 L1_N116 L2_N19 1.6575688686e+05
R_Dense_2_117_19 L1_N117 L2_N19 9.9034833500e+05
R_Dense_2_118_19 L1_N118 L2_N19 1.2994894577e+05
R_Dense_2_119_19 L1_N119 L2_N19 5.6066954669e+05
R_Dense_2_120_19 L1_N120 L2_N19 3.3027734562e+05
R_Dense_2_121_19 L1_N121 L2_N19 1.4792430939e+05
R_Dense_2_122_19 L1_N122 L2_N19 1.3117955639e+05
R_Dense_2_123_19 L1_N123 L2_N19 2.7391962745e+05
R_Dense_2_124_19 L1_N124 L2_N19 3.6416902305e+05
R_Dense_2_125_19 L1_N125 L2_N19 2.4772684107e+05
R_Dense_2_126_19 L1_N126 L2_N19 1.3111262894e+05
R_Dense_2_127_19 L1_N127 L2_N19 4.1228106292e+05
R_Dense_2_128_19 L1_N128 L2_N19 3.9125178842e+05
R_Dense_2_129_19 L1_N129 L2_N19 1.3918856023e+05
R_Dense_2_130_19 L1_N130 L2_N19 1.4716945376e+05
R_Dense_2_131_19 L1_N131 L2_N19 1.0185674417e+05
R_Dense_2_132_19 L1_N132 L2_N19 2.6587101978e+05
R_Dense_2_133_19 L1_N133 L2_N19 1.0456277722e+05
R_Dense_2_134_19 L1_N134 L2_N19 1.1267711821e+06
R_Dense_2_135_19 L1_N135 L2_N19 1.0248358866e+05
R_Dense_2_136_19 L1_N136 L2_N19 1.0495791467e+05
R_Dense_2_137_19 L1_N137 L2_N19 1.7882099896e+05
R_Dense_2_138_19 L1_N138 L2_N19 1.4603380559e+05
R_Dense_2_139_19 L1_N139 L2_N19 1.1996870223e+05
R_Dense_2_140_19 L1_N140 L2_N19 1.1726054480e+05
R_Dense_2_141_19 L1_N141 L2_N19 1.4132233316e+05
R_Dense_2_142_19 L1_N142 L2_N19 6.7183146672e+05
R_Dense_2_143_19 L1_N143 L2_N19 1.1029693490e+05
R_Dense_2_144_19 L1_N144 L2_N19 1.2479936513e+06
R_Dense_2_145_19 L1_N145 L2_N19 1.3759786887e+05
R_Dense_2_146_19 L1_N146 L2_N19 1.2244193668e+05
R_Dense_2_147_19 L1_N147 L2_N19 1.4790126919e+05
R_Dense_2_148_19 L1_N148 L2_N19 3.2793709583e+05
R_Dense_2_149_19 L1_N149 L2_N19 1.1986314492e+05
R_Dense_2_150_19 L1_N150 L2_N19 1.1008464593e+05
R_Dense_2_151_19 L1_N151 L2_N19 1.8544379757e+05
R_Dense_2_152_19 L1_N152 L2_N19 1.6710652326e+05
R_Dense_2_153_19 L1_N153 L2_N19 2.0746593845e+05
R_Dense_2_154_19 L1_N154 L2_N19 2.4433485697e+05
R_Dense_2_155_19 L1_N155 L2_N19 1.7235140860e+05
R_Dense_2_156_19 L1_N156 L2_N19 1.2931128765e+05
R_Dense_2_157_19 L1_N157 L2_N19 2.6717873062e+05
R_Dense_2_158_19 L1_N158 L2_N19 2.2133953935e+05
R_Dense_2_159_19 L1_N159 L2_N19 1.3310785448e+05
R_Dense_2_160_19 L1_N160 L2_N19 1.4520058909e+05
R_Dense_2_161_19 L1_N161 L2_N19 1.0415391085e+05
R_Dense_2_162_19 L1_N162 L2_N19 1.0383303763e+05
R_Dense_2_163_19 L1_N163 L2_N19 1.5614992462e+06
R_Dense_2_164_19 L1_N164 L2_N19 1.0180941395e+05
R_Dense_2_165_19 L1_N165 L2_N19 1.3564400205e+05
R_Dense_2_166_19 L1_N166 L2_N19 3.8240071768e+05
R_Dense_2_167_19 L1_N167 L2_N19 1.6720038524e+05
R_Dense_2_168_19 L1_N168 L2_N19 2.3199580104e+05
R_Dense_2_169_19 L1_N169 L2_N19 8.2669126989e+05
R_Dense_2_170_19 L1_N170 L2_N19 1.0142392708e+05
R_Dense_2_171_19 L1_N171 L2_N19 2.1693005445e+05
R_Dense_2_172_19 L1_N172 L2_N19 1.1880906202e+05
R_Dense_2_173_19 L1_N173 L2_N19 1.2015162261e+05
R_Dense_2_174_19 L1_N174 L2_N19 1.1111164989e+05
R_Dense_2_175_19 L1_N175 L2_N19 1.3899170564e+05
R_Dense_2_176_19 L1_N176 L2_N19 3.8202527528e+05
R_Dense_2_177_19 L1_N177 L2_N19 2.2589320573e+05
R_Dense_2_178_19 L1_N178 L2_N19 1.2822693512e+05
R_Dense_2_179_19 L1_N179 L2_N19 2.6180239142e+05
R_Dense_2_180_19 L1_N180 L2_N19 2.6281007489e+05
R_Dense_2_181_19 L1_N181 L2_N19 5.9774600464e+05
R_Dense_2_182_19 L1_N182 L2_N19 1.3013174939e+05
R_Dense_2_183_19 L1_N183 L2_N19 4.0780453436e+05
R_Dense_2_184_19 L1_N184 L2_N19 4.1735032313e+05
R_Dense_2_185_19 L1_N185 L2_N19 1.1051528243e+05
R_Dense_2_186_19 L1_N186 L2_N19 1.5033920806e+05
R_Dense_2_187_19 L1_N187 L2_N19 2.5518628076e+05
R_Dense_2_188_19 L1_N188 L2_N19 1.3288531305e+05
R_Dense_2_189_19 L1_N189 L2_N19 3.7849033360e+05
R_Dense_2_190_19 L1_N190 L2_N19 1.6724131560e+05
R_Dense_2_191_19 L1_N191 L2_N19 3.9501889950e+05
R_Dense_2_192_19 L1_N192 L2_N19 1.0693186522e+05
R_Dense_2_193_19 L1_N193 L2_N19 4.0666846508e+06
R_Dense_2_194_19 L1_N194 L2_N19 8.6491140308e+06
R_Dense_2_195_19 L1_N195 L2_N19 3.9718404241e+05
R_Dense_2_196_19 L1_N196 L2_N19 5.4661700412e+05
R_Dense_2_197_19 L1_N197 L2_N19 2.2342231449e+05
R_Dense_2_198_19 L1_N198 L2_N19 2.7444594980e+06
R_Dense_2_199_19 L1_N199 L2_N19 1.2304739108e+05
R_Dense_2_200_19 L1_N200 L2_N19 1.4036934128e+05
R_Dense_2_201_19 L1_N201 L2_N19 1.3678297887e+05
R_Dense_2_202_19 L1_N202 L2_N19 1.1301666029e+05
R_Dense_2_203_19 L1_N203 L2_N19 3.3184816491e+05
R_Dense_2_204_19 L1_N204 L2_N19 1.1603296104e+05
R_Dense_2_205_19 L1_N205 L2_N19 2.7849141693e+05
R_Dense_2_206_19 L1_N206 L2_N19 1.5240220770e+05
R_Dense_2_207_19 L1_N207 L2_N19 9.9071457646e+05
R_Dense_2_208_19 L1_N208 L2_N19 6.0356512921e+05
R_Dense_2_209_19 L1_N209 L2_N19 1.0836979072e+05
R_Dense_2_210_19 L1_N210 L2_N19 9.2768627861e+05
R_Dense_2_211_19 L1_N211 L2_N19 2.0192308092e+05
R_Dense_2_212_19 L1_N212 L2_N19 2.5735813712e+05
R_Dense_2_213_19 L1_N213 L2_N19 1.9578806530e+05
R_Dense_2_214_19 L1_N214 L2_N19 5.7909220873e+05
R_Dense_2_215_19 L1_N215 L2_N19 2.8355080929e+05
R_Dense_2_216_19 L1_N216 L2_N19 1.2758193878e+05
R_Dense_2_217_19 L1_N217 L2_N19 1.2823965880e+05
R_Dense_2_218_19 L1_N218 L2_N19 2.2886978607e+05
R_Dense_2_219_19 L1_N219 L2_N19 5.3469947114e+05
R_Dense_2_220_19 L1_N220 L2_N19 1.4172348042e+05
R_Dense_2_221_19 L1_N221 L2_N19 2.0178449726e+05
R_Dense_2_222_19 L1_N222 L2_N19 1.5823367369e+05
R_Dense_2_223_19 L1_N223 L2_N19 3.2395349571e+06
R_Dense_2_224_19 L1_N224 L2_N19 4.2610977876e+05
R_Dense_2_225_19 L1_N225 L2_N19 1.0668894969e+05
R_Dense_2_226_19 L1_N226 L2_N19 3.8982868163e+05
R_Dense_2_227_19 L1_N227 L2_N19 3.3804780248e+05
R_Dense_2_228_19 L1_N228 L2_N19 1.4969957919e+05
R_Dense_2_229_19 L1_N229 L2_N19 1.2730798094e+05
R_Dense_2_230_19 L1_N230 L2_N19 1.1323255369e+05
R_Dense_2_231_19 L1_N231 L2_N19 1.9259768884e+05
R_Dense_2_232_19 L1_N232 L2_N19 1.0037580943e+05
R_Dense_2_233_19 L1_N233 L2_N19 1.8788749956e+05
R_Dense_2_234_19 L1_N234 L2_N19 1.6611107090e+05
R_Dense_2_235_19 L1_N235 L2_N19 1.5379402340e+06
R_Dense_2_236_19 L1_N236 L2_N19 4.0647885045e+05
R_Dense_2_237_19 L1_N237 L2_N19 1.3892785061e+05
R_Dense_2_238_19 L1_N238 L2_N19 1.6001690582e+05
R_Dense_2_239_19 L1_N239 L2_N19 6.7672825253e+05
R_Dense_2_240_19 L1_N240 L2_N19 1.9856490765e+05
R_Dense_2_241_19 L1_N241 L2_N19 1.0351962722e+05
R_Dense_2_242_19 L1_N242 L2_N19 4.7113347573e+05
R_Dense_2_243_19 L1_N243 L2_N19 3.0488498144e+05
R_Dense_2_244_19 L1_N244 L2_N19 1.5354780242e+05
R_Dense_2_245_19 L1_N245 L2_N19 1.3555516506e+05
R_Dense_2_246_19 L1_N246 L2_N19 1.3834297696e+05
R_Dense_2_247_19 L1_N247 L2_N19 1.0756058119e+05
R_Dense_2_248_19 L1_N248 L2_N19 1.4357440903e+05
R_Dense_2_249_19 L1_N249 L2_N19 3.6276701504e+05
R_Dense_2_250_19 L1_N250 L2_N19 8.4588718274e+05
R_Dense_2_251_19 L1_N251 L2_N19 4.7715132925e+05
R_Dense_2_252_19 L1_N252 L2_N19 2.9388578401e+05
R_Dense_2_253_19 L1_N253 L2_N19 1.6651666762e+05
R_Dense_2_254_19 L1_N254 L2_N19 1.2199794222e+05
R_Dense_2_255_19 L1_N255 L2_N19 3.9919338604e+05
R_Dense_2_256_19 L1_N256 L2_N19 3.5236504520e+05
R_Dense_2_257_19 L1_N257 L2_N19 4.8823328493e+05
R_Dense_2_258_19 L1_N258 L2_N19 2.2866046249e+05
R_Dense_2_259_19 L1_N259 L2_N19 5.6805019755e+06
R_Dense_2_260_19 L1_N260 L2_N19 4.8111820156e+05
R_Dense_2_261_19 L1_N261 L2_N19 3.2277888534e+05
R_Dense_2_262_19 L1_N262 L2_N19 2.9332859669e+05
R_Dense_2_263_19 L1_N263 L2_N19 2.2766744730e+05
R_Dense_2_264_19 L1_N264 L2_N19 2.1242717110e+05
R_Dense_2_265_19 L1_N265 L2_N19 1.0049050284e+05
R_Dense_2_266_19 L1_N266 L2_N19 3.0591430918e+05
R_Dense_2_267_19 L1_N267 L2_N19 1.1760512817e+06
R_Dense_2_268_19 L1_N268 L2_N19 1.1634080386e+05
R_Dense_2_269_19 L1_N269 L2_N19 1.7777691833e+05
R_Dense_2_270_19 L1_N270 L2_N19 1.3984742476e+06
R_Dense_2_271_19 L1_N271 L2_N19 1.9840722242e+05
R_Dense_2_272_19 L1_N272 L2_N19 2.5331623228e+06
R_Dense_2_273_19 L1_N273 L2_N19 2.3708995349e+05
R_Dense_2_274_19 L1_N274 L2_N19 2.7387278953e+05
R_Dense_2_275_19 L1_N275 L2_N19 3.2288145734e+05
R_Dense_2_276_19 L1_N276 L2_N19 1.9721430629e+05
R_Dense_2_277_19 L1_N277 L2_N19 3.0697675701e+05
R_Dense_2_278_19 L1_N278 L2_N19 6.6892712903e+05
R_Dense_2_279_19 L1_N279 L2_N19 1.2272291182e+05
R_Dense_2_280_19 L1_N280 L2_N19 1.0959778001e+05
R_Dense_2_281_19 L1_N281 L2_N19 1.6526896222e+05
R_Dense_2_282_19 L1_N282 L2_N19 1.1561447290e+05
R_Dense_2_283_19 L1_N283 L2_N19 4.0692987092e+05
R_Dense_2_284_19 L1_N284 L2_N19 5.0167098682e+05
R_Dense_2_285_19 L1_N285 L2_N19 1.3695939146e+05
R_Dense_2_286_19 L1_N286 L2_N19 1.1825454380e+05
R_Dense_2_287_19 L1_N287 L2_N19 1.5850490683e+05
R_Dense_2_288_19 L1_N288 L2_N19 1.5984706752e+05
R_Dense_2_289_19 L1_N289 L2_N19 1.6774761077e+05
R_Dense_2_290_19 L1_N290 L2_N19 1.0317609579e+05
R_Dense_2_291_19 L1_N291 L2_N19 1.3819926185e+05
R_Dense_2_292_19 L1_N292 L2_N19 4.8188042182e+06
R_Dense_2_293_19 L1_N293 L2_N19 1.1038257227e+05
R_Dense_2_294_19 L1_N294 L2_N19 1.7262619141e+06
R_Dense_2_295_19 L1_N295 L2_N19 1.0178554608e+06
R_Dense_2_296_19 L1_N296 L2_N19 2.1732953726e+05
R_Dense_2_297_19 L1_N297 L2_N19 1.2884591696e+05
R_Dense_2_298_19 L1_N298 L2_N19 3.1629688365e+05
R_Dense_2_299_19 L1_N299 L2_N19 1.1261155508e+06
R_Dense_2_300_19 L1_N300 L2_N19 1.4503844337e+06
R_Dense_2_301_19 L1_N301 L2_N19 5.4294240929e+05
R_Dense_2_302_19 L1_N302 L2_N19 1.5610215347e+05
R_Dense_2_303_19 L1_N303 L2_N19 1.5020700128e+05
R_Dense_2_304_19 L1_N304 L2_N19 1.3391568244e+05
R_Dense_2_305_19 L1_N305 L2_N19 2.3519932911e+05
R_Dense_2_306_19 L1_N306 L2_N19 1.4267660005e+05
R_Dense_2_307_19 L1_N307 L2_N19 5.6685228342e+05
R_Dense_2_308_19 L1_N308 L2_N19 2.9144667670e+05
R_Dense_2_309_19 L1_N309 L2_N19 1.1290797511e+05
R_Dense_2_310_19 L1_N310 L2_N19 1.2510524838e+06
R_Dense_2_311_19 L1_N311 L2_N19 1.2049672898e+05
R_Dense_2_312_19 L1_N312 L2_N19 1.3365263724e+05
R_Dense_2_313_19 L1_N313 L2_N19 2.4347317021e+05
R_Dense_2_314_19 L1_N314 L2_N19 2.4578994025e+05
R_Dense_2_315_19 L1_N315 L2_N19 1.9393048767e+06
R_Dense_2_316_19 L1_N316 L2_N19 1.4382567884e+05
R_Dense_2_317_19 L1_N317 L2_N19 1.1064761733e+05
R_Dense_2_318_19 L1_N318 L2_N19 2.9107713467e+05
R_Dense_2_319_19 L1_N319 L2_N19 4.1779018440e+05
R_Dense_2_320_19 L1_N320 L2_N19 1.8718792025e+05
R_Dense_2_321_19 L1_N321 L2_N19 5.5996968067e+05
R_Dense_2_322_19 L1_N322 L2_N19 1.2004844315e+05
R_Dense_2_323_19 L1_N323 L2_N19 2.2975144996e+05
R_Dense_2_324_19 L1_N324 L2_N19 3.1545083783e+05
R_Dense_2_325_19 L1_N325 L2_N19 1.0878638459e+05
R_Dense_2_326_19 L1_N326 L2_N19 1.8884401924e+05
R_Dense_2_327_19 L1_N327 L2_N19 2.7299799367e+05
R_Dense_2_328_19 L1_N328 L2_N19 1.6556239653e+06
R_Dense_2_329_19 L1_N329 L2_N19 8.0732874137e+06
R_Dense_2_330_19 L1_N330 L2_N19 1.1468650299e+05
R_Dense_2_331_19 L1_N331 L2_N19 1.1077560135e+05
R_Dense_2_332_19 L1_N332 L2_N19 6.7752016076e+05
R_Dense_2_333_19 L1_N333 L2_N19 1.7503977335e+05
R_Dense_2_334_19 L1_N334 L2_N19 1.2580366333e+05
R_Dense_2_335_19 L1_N335 L2_N19 2.9416966057e+05
R_Dense_2_336_19 L1_N336 L2_N19 8.5048593786e+05
R_Dense_2_337_19 L1_N337 L2_N19 1.5375938767e+06
I_in_0 L2_N0 0 DC 9.3163358696e-06
I_in_1 L2_N1 0 DC 1.4768720275e-06
I_in_2 L2_N2 0 DC 9.4250249814e-07
I_in_3 L2_N3 0 DC 5.8987132572e-06
I_in_4 L2_N4 0 DC 3.0444256158e-06
I_in_5 L2_N5 0 DC 5.5342452122e-06
I_in_6 L2_N6 0 DC 4.6549612259e-06
I_in_7 L2_N7 0 DC 6.1238183257e-06
I_in_8 L2_N8 0 DC 8.7823986938e-06
I_in_9 L2_N9 0 DC 6.2712034436e-06
I_in_10 L2_N10 0 DC 8.0326968740e-06
I_in_11 L2_N11 0 DC 6.3905060930e-07
I_in_12 L2_N12 0 DC 3.8813787986e-06
I_in_13 L2_N13 0 DC 3.1653124491e-06
I_in_14 L2_N14 0 DC 5.5717999476e-06
I_in_15 L2_N15 0 DC 1.6940094110e-06
I_in_16 L2_N16 0 DC 8.2259738717e-07
I_in_17 L2_N17 0 DC 2.1549862190e-06
I_in_18 L2_N18 0 DC 3.5028857473e-06
I_in_19 L2_N19 0 DC 2.4621493854e-06
.control
op
print V(L2_N0) V(L2_N1) V(L2_N2) V(L2_N3) V(L2_N4) V(L2_N5) V(L2_N6) V(L2_N7) V(L2_N8) V(L2_N9) V(L2_N10) V(L2_N11) V(L2_N12) V(L2_N13) V(L2_N14) V(L2_N15) V(L2_N16) V(L2_N17) V(L2_N18) V(L2_N19)
.endc
.end
